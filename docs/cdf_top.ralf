        register sip5_cdf_axi_I_main_TransactionStatFilter_UserBase @0x24 {
            bytes 4;
            field USERBASE @'h0 {
                bits 27;
                access rw;
                hard_reset 'h0;
                doc {
                    This register contains the User base used to filter requests.
                }
            }
        }
        register sip5_cdf_axi_I_main_TransactionStatFilter_UserMask @0x28 {
            bytes 4;
            field USERMASK @'h0 {
                bits 27;
                access rw;
                hard_reset 'h0;
                doc {
                    This register contains the User mask used to filter requests.
                }
            }
        }
        register sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_03 @0x2C {
            bytes 4;
            field sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_03 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_04 @0x30 {
            bytes 4;
            field sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_04 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_05 @0x34 {
            bytes 4;
            field sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_05 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_06 @0x38 {
            bytes 4;
            field sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_06 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_07 @0x3C {
            bytes 4;
            field sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_07 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_08 @0x40 {
            bytes 4;
            field sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_08 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_09 @0x44 {
            bytes 4;
            field sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_09 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_10 @0x48 {
            bytes 4;
            field sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_10 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_11 @0x4C {
            bytes 4;
            field sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_11 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_12 @0x50 {
            bytes 4;
            field sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_12 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_13 @0x54 {
            bytes 4;
            field sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_13 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_14 @0x58 {
            bytes 4;
            field sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_14 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_15 @0x5C {
            bytes 4;
            field sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_15 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_16 @0x60 {
            bytes 4;
            field sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_16 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_17 @0x64 {
            bytes 4;
            field sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_17 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_18 @0x68 {
            bytes 4;
            field sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_18 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_19 @0x6C {
            bytes 4;
            field sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_19 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_20 @0x70 {
            bytes 4;
            field sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_20 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_21 @0x74 {
            bytes 4;
            field sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_21 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_22 @0x78 {
            bytes 4;
            field sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_22 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_23 @0x7C {
            bytes 4;
            field sip5_cdf_axi_I_main_TransactionStatFilter_Reserved_23 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
    }
    block sip6_cdf_axi_I_main_TransactionStatFilter @0x6400 {
        bytes 4;
        register sip6_cdf_axi_I_main_TransactionStatFilter_Id_CoreId @0x0 {
            bytes 4;
            field CORETYPEID @'h0 {
                bits 8;
                access ro;
                hard_reset 'h9;
                doc {
                    Field identifying the type of IP.
                }
            }
            field CORECHECKSUM @'h8 {
                bits 24;
                access ro;
                hard_reset 'hf17f7c;
                doc {
                    Field containing a checksum of the parameters of the IP.
                }
            }
        }
        register sip6_cdf_axi_I_main_TransactionStatFilter_Id_RevisionId @0x4 {
            bytes 4;
            field USERID @'h0 {
                bits 8;
                access ro;
                hard_reset 'h0;
                doc {
                    Field containing a user defined value, not used anywhere inside the IP itself.
                }
            }
            field FLEXNOCID @'h8 {
                bits 24;
                access ro;
                hard_reset 'h84f8c6;
                doc {
                    Field containing the build revision of the software used to generate the IP HDL code.
                }
            }
        }
        register sip6_cdf_axi_I_main_TransactionStatFilter_Mode @0x8 {
            bytes 4;
            field MODE @'h0 {
                access rw;
                hard_reset 'h0;
                doc {
                    Register Mode is a 1-bit register that sets the filtering mode as follows: handshake Mode = 0 or latency Mode = 1.
                }
            }
        }
        register sip6_cdf_axi_I_main_TransactionStatFilter_AddrBase_Low @0xC {
            bytes 4;
            field ADDRBASE_LOW @'h0 {
                bits 23;
                access rw;
                hard_reset 'h0;
                doc {
                    Address base LSB register.
                }
            }
        }
        register sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_00 @0x10 {
            bytes 4;
            field sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_00 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_TransactionStatFilter_AddrWindowSize @0x14 {
            bytes 4;
            field ADDRWINDOWSIZE @'h0 {
                bits 5;
                access rw;
                hard_reset 'h0;
                doc {
                    Register AddrWindowSize contains the encoded address mask used to filter packets: the effective Mask value is equal to ~(2**AddrWindowSize - 1). A packet is a candidate when ReqInfo.Addr & AddrMask = AddrBase & AddrMask.
                }
            }
        }
        register sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_01 @0x18 {
            bytes 4;
            field sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_01 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_02 @0x1C {
            bytes 4;
            field sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_02 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_TransactionStatFilter_Opcode @0x20 {
            bytes 4;
            field RDEN @'h0 {
                access rw;
                hard_reset 'h0;
                doc {
                    When set to 1, selects RD requests.
                }
            }
            field WREN @'h1 {
                access rw;
                hard_reset 'h0;
                doc {
                    When set to 1, selects WR requests.
                }
            }
            doc {
                This register selects candidate packets based on packet opcodes. (0 disables the filter):
	This register selects candidate packets based on packet opcodes. (0 disables the filter):
	
            }
        }
        register sip6_cdf_axi_I_main_TransactionStatFilter_UserBase @0x24 {
            bytes 4;
            field USERBASE @'h0 {
                bits 27;
                access rw;
                hard_reset 'h0;
                doc {
                    This register contains the User base used to filter requests.
                }
            }
        }
        register sip6_cdf_axi_I_main_TransactionStatFilter_UserMask @0x28 {
            bytes 4;
            field USERMASK @'h0 {
                bits 27;
                access rw;
                hard_reset 'h0;
                doc {
                    This register contains the User mask used to filter requests.
                }
            }
        }
        register sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_03 @0x2C {
            bytes 4;
            field sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_03 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_04 @0x30 {
            bytes 4;
            field sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_04 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_05 @0x34 {
            bytes 4;
            field sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_05 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_06 @0x38 {
            bytes 4;
            field sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_06 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_07 @0x3C {
            bytes 4;
            field sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_07 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_08 @0x40 {
            bytes 4;
            field sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_08 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_09 @0x44 {
            bytes 4;
            field sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_09 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_10 @0x48 {
            bytes 4;
            field sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_10 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_11 @0x4C {
            bytes 4;
            field sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_11 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_12 @0x50 {
            bytes 4;
            field sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_12 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_13 @0x54 {
            bytes 4;
            field sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_13 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_14 @0x58 {
            bytes 4;
            field sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_14 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_15 @0x5C {
            bytes 4;
            field sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_15 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_16 @0x60 {
            bytes 4;
            field sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_16 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_17 @0x64 {
            bytes 4;
            field sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_17 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_18 @0x68 {
            bytes 4;
            field sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_18 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_19 @0x6C {
            bytes 4;
            field sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_19 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_20 @0x70 {
            bytes 4;
            field sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_20 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_21 @0x74 {
            bytes 4;
            field sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_21 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_22 @0x78 {
            bytes 4;
            field sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_22 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_23 @0x7C {
            bytes 4;
            field sip6_cdf_axi_I_main_TransactionStatFilter_Reserved_23 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
    }
    block sip7_cdf_axi_I_main_TransactionStatFilter @0x6480 {
        bytes 4;
        register sip7_cdf_axi_I_main_TransactionStatFilter_Id_CoreId @0x0 {
            bytes 4;
            field CORETYPEID @'h0 {
                bits 8;
                access ro;
                hard_reset 'h9;
                doc {
                    Field identifying the type of IP.
                }
            }
            field CORECHECKSUM @'h8 {
                bits 24;
                access ro;
                hard_reset 'hba573b;
                doc {
                    Field containing a checksum of the parameters of the IP.
                }
            }
        }
        register sip7_cdf_axi_I_main_TransactionStatFilter_Id_RevisionId @0x4 {
            bytes 4;
            field USERID @'h0 {
                bits 8;
                access ro;
                hard_reset 'h0;
                doc {
                    Field containing a user defined value, not used anywhere inside the IP itself.
                }
            }
            field FLEXNOCID @'h8 {
                bits 24;
                access ro;
                hard_reset 'h84f8c6;
                doc {
                    Field containing the build revision of the software used to generate the IP HDL code.
                }
            }
        }
        register sip7_cdf_axi_I_main_TransactionStatFilter_Mode @0x8 {
            bytes 4;
            field MODE @'h0 {
                access rw;
                hard_reset 'h0;
                doc {
                    Register Mode is a 1-bit register that sets the filtering mode as follows: handshake Mode = 0 or latency Mode = 1.
                }
            }
        }
        register sip7_cdf_axi_I_main_TransactionStatFilter_AddrBase_Low @0xC {
            bytes 4;
            field ADDRBASE_LOW @'h0 {
                bits 23;
                access rw;
                hard_reset 'h0;
                doc {
                    Address base LSB register.
                }
            }
        }
        register sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_00 @0x10 {
            bytes 4;
            field sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_00 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_TransactionStatFilter_AddrWindowSize @0x14 {
            bytes 4;
            field ADDRWINDOWSIZE @'h0 {
                bits 5;
                access rw;
                hard_reset 'h0;
                doc {
                    Register AddrWindowSize contains the encoded address mask used to filter packets: the effective Mask value is equal to ~(2**AddrWindowSize - 1). A packet is a candidate when ReqInfo.Addr & AddrMask = AddrBase & AddrMask.
                }
            }
        }
        register sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_01 @0x18 {
            bytes 4;
            field sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_01 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_02 @0x1C {
            bytes 4;
            field sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_02 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_TransactionStatFilter_Opcode @0x20 {
            bytes 4;
            field RDEN @'h0 {
                access rw;
                hard_reset 'h0;
                doc {
                    When set to 1, selects RD requests.
                }
            }
            field WREN @'h1 {
                access rw;
                hard_reset 'h0;
                doc {
                    When set to 1, selects WR requests.
                }
            }
            doc {
                This register selects candidate packets based on packet opcodes. (0 disables the filter):
	This register selects candidate packets based on packet opcodes. (0 disables the filter):
	
            }
        }
        register sip7_cdf_axi_I_main_TransactionStatFilter_UserBase @0x24 {
            bytes 4;
            field USERBASE @'h0 {
                bits 27;
                access rw;
                hard_reset 'h0;
                doc {
                    This register contains the User base used to filter requests.
                }
            }
        }
        register sip7_cdf_axi_I_main_TransactionStatFilter_UserMask @0x28 {
            bytes 4;
            field USERMASK @'h0 {
                bits 27;
                access rw;
                hard_reset 'h0;
                doc {
                    This register contains the User mask used to filter requests.
                }
            }
        }
        register sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_03 @0x2C {
            bytes 4;
            field sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_03 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_04 @0x30 {
            bytes 4;
            field sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_04 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_05 @0x34 {
            bytes 4;
            field sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_05 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_06 @0x38 {
            bytes 4;
            field sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_06 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_07 @0x3C {
            bytes 4;
            field sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_07 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_08 @0x40 {
            bytes 4;
            field sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_08 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_09 @0x44 {
            bytes 4;
            field sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_09 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_10 @0x48 {
            bytes 4;
            field sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_10 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_11 @0x4C {
            bytes 4;
            field sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_11 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_12 @0x50 {
            bytes 4;
            field sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_12 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_13 @0x54 {
            bytes 4;
            field sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_13 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_14 @0x58 {
            bytes 4;
            field sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_14 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_15 @0x5C {
            bytes 4;
            field sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_15 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_16 @0x60 {
            bytes 4;
            field sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_16 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_17 @0x64 {
            bytes 4;
            field sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_17 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_18 @0x68 {
            bytes 4;
            field sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_18 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_19 @0x6C {
            bytes 4;
            field sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_19 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_20 @0x70 {
            bytes 4;
            field sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_20 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_21 @0x74 {
            bytes 4;
            field sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_21 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_22 @0x78 {
            bytes 4;
            field sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_22 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_23 @0x7C {
            bytes 4;
            field sip7_cdf_axi_I_main_TransactionStatFilter_Reserved_23 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
    }
    block cdf_observer_main_AtbEndPoint @0x7000 {
        bytes 4;
        register cdf_observer_main_AtbEndPoint_Id_CoreId @0x0 {
            bytes 4;
            field CORETYPEID @'h0 {
                bits 8;
                access ro;
                hard_reset 'h7;
                doc {
                    Field identifying the type of IP.
                }
            }
            field CORECHECKSUM @'h8 {
                bits 24;
                access ro;
                hard_reset 'hb80dfa;
                doc {
                    Field containing a checksum of the parameters of the IP.
                }
            }
        }
        register cdf_observer_main_AtbEndPoint_Id_RevisionId @0x4 {
            bytes 4;
            field USERID @'h0 {
                bits 8;
                access ro;
                hard_reset 'h0;
                doc {
                    Field containing a user defined value, not used anywhere inside the IP itself.
                }
            }
            field FLEXNOCID @'h8 {
                bits 24;
                access ro;
                hard_reset 'h84f8c6;
                doc {
                    Field containing the build revision of the software used to generate the IP HDL code.
                }
            }
        }
        register cdf_observer_main_AtbEndPoint_AtbId @0x8 {
            bytes 4;
            field ATBID @'h0 {
                bits 7;
                access rw;
                hard_reset 'h1;
                doc {
                    ATB AtId
                }
            }
        }
        register cdf_observer_main_AtbEndPoint_AtbEn @0xC {
            bytes 4;
            field ATBEN @'h0 {
                access rw;
                hard_reset 'h0;
                doc {
                    ATB Unit Enable
                }
            }
        }
        register cdf_observer_main_AtbEndPoint_SyncPeriod @0x10 {
            bytes 4;
            field SYNCPERIOD @'h0 {
                bits 5;
                access rw;
                hard_reset 'h0;
                doc {
                    ATB Synchro Period
                }
            }
        }
        register cdf_observer_main_AtbEndPoint_Reserved_00 @0x14 {
            bytes 4;
            field cdf_observer_main_AtbEndPoint_Reserved_00 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_AtbEndPoint_Reserved_01 @0x18 {
            bytes 4;
            field cdf_observer_main_AtbEndPoint_Reserved_01 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_AtbEndPoint_Reserved_02 @0x1C {
            bytes 4;
            field cdf_observer_main_AtbEndPoint_Reserved_02 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_AtbEndPoint_Reserved_03 @0x20 {
            bytes 4;
            field cdf_observer_main_AtbEndPoint_Reserved_03 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_AtbEndPoint_Reserved_04 @0x24 {
            bytes 4;
            field cdf_observer_main_AtbEndPoint_Reserved_04 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_AtbEndPoint_Reserved_05 @0x28 {
            bytes 4;
            field cdf_observer_main_AtbEndPoint_Reserved_05 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_AtbEndPoint_Reserved_06 @0x2C {
            bytes 4;
            field cdf_observer_main_AtbEndPoint_Reserved_06 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_AtbEndPoint_Reserved_07 @0x30 {
            bytes 4;
            field cdf_observer_main_AtbEndPoint_Reserved_07 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_AtbEndPoint_Reserved_08 @0x34 {
            bytes 4;
            field cdf_observer_main_AtbEndPoint_Reserved_08 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_AtbEndPoint_Reserved_09 @0x38 {
            bytes 4;
            field cdf_observer_main_AtbEndPoint_Reserved_09 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_AtbEndPoint_Reserved_10 @0x3C {
            bytes 4;
            field cdf_observer_main_AtbEndPoint_Reserved_10 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_AtbEndPoint_Reserved_11 @0x40 {
            bytes 4;
            field cdf_observer_main_AtbEndPoint_Reserved_11 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_AtbEndPoint_Reserved_12 @0x44 {
            bytes 4;
            field cdf_observer_main_AtbEndPoint_Reserved_12 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_AtbEndPoint_Reserved_13 @0x48 {
            bytes 4;
            field cdf_observer_main_AtbEndPoint_Reserved_13 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_AtbEndPoint_Reserved_14 @0x4C {
            bytes 4;
            field cdf_observer_main_AtbEndPoint_Reserved_14 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_AtbEndPoint_Reserved_15 @0x50 {
            bytes 4;
            field cdf_observer_main_AtbEndPoint_Reserved_15 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_AtbEndPoint_Reserved_16 @0x54 {
            bytes 4;
            field cdf_observer_main_AtbEndPoint_Reserved_16 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_AtbEndPoint_Reserved_17 @0x58 {
            bytes 4;
            field cdf_observer_main_AtbEndPoint_Reserved_17 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_AtbEndPoint_Reserved_18 @0x5C {
            bytes 4;
            field cdf_observer_main_AtbEndPoint_Reserved_18 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_AtbEndPoint_Reserved_19 @0x60 {
            bytes 4;
            field cdf_observer_main_AtbEndPoint_Reserved_19 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_AtbEndPoint_Reserved_20 @0x64 {
            bytes 4;
            field cdf_observer_main_AtbEndPoint_Reserved_20 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_AtbEndPoint_Reserved_21 @0x68 {
            bytes 4;
            field cdf_observer_main_AtbEndPoint_Reserved_21 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_AtbEndPoint_Reserved_22 @0x6C {
            bytes 4;
            field cdf_observer_main_AtbEndPoint_Reserved_22 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_AtbEndPoint_Reserved_23 @0x70 {
            bytes 4;
            field cdf_observer_main_AtbEndPoint_Reserved_23 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_AtbEndPoint_Reserved_24 @0x74 {
            bytes 4;
            field cdf_observer_main_AtbEndPoint_Reserved_24 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_AtbEndPoint_Reserved_25 @0x78 {
            bytes 4;
            field cdf_observer_main_AtbEndPoint_Reserved_25 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_AtbEndPoint_Reserved_26 @0x7C {
            bytes 4;
            field cdf_observer_main_AtbEndPoint_Reserved_26 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
    }
    block cdf_observer_main_ErrorLogger_0 @0x7400 {
        bytes 4;
        register cdf_observer_main_ErrorLogger_0_Id_CoreId @0x0 {
            bytes 4;
            field CORETYPEID @'h0 {
                bits 8;
                access ro;
                hard_reset 'hd;
                doc {
                    Field identifying the type of IP.
                }
            }
            field CORECHECKSUM @'h8 {
                bits 24;
                access ro;
                hard_reset 'h5c03ed;
                doc {
                    Field containing a checksum of the parameters of the IP.
                }
            }
        }
        register cdf_observer_main_ErrorLogger_0_Id_RevisionId @0x4 {
            bytes 4;
            field USERID @'h0 {
                bits 8;
                access ro;
                hard_reset 'h0;
                doc {
                    Field containing a user defined value, not used anywhere inside the IP itself.
                }
            }
            field FLEXNOCID @'h8 {
                bits 24;
                access ro;
                hard_reset 'h84f8c6;
                doc {
                    Field containing the build revision of the software used to generate the IP HDL code.
                }
            }
        }
        register cdf_observer_main_ErrorLogger_0_FaultEn @0x8 {
            bytes 4;
            field FAULTEN @'h0 {
                access rw;
                hard_reset 'h0;
                doc {
                    Set to 1 to enable output signal Fault. Fault asserted when ErrVld is 1.
                }
            }
        }
        register cdf_observer_main_ErrorLogger_0_ErrVld @0xC {
            bytes 4;
            field ERRVLD @'h0 {
                access ro;
                hard_reset 'h0;
                doc {
                    1 indicates an error has been logged
                }
            }
        }
        register cdf_observer_main_ErrorLogger_0_ErrClr @0x10 {
            bytes 4;
            field ERRCLR @'h0 {
                access w1c;
                hard_reset 'h0;
                doc {
                    Set to 1 to clear ErrVld. NOTE The written value is not stored in ErrVld. A read always returns 0.
                }
            }
        }
        register cdf_observer_main_ErrorLogger_0_ErrLog0 @0x14 {
            bytes 4;
            field LOCK @'h0 {
                access ro;
                hard_reset 'h0;
                doc {
                    Lock
                }
            }
            field OPC @'h1 {
                bits 4;
                access ro;
                hard_reset 'h0;
                doc {
                    Opc
                }
            }
            field ERRCODE @'h8 {
                bits 3;
                access ro;
                hard_reset 'h0;
                doc {
                    ErrCode
                }
            }
            field LEN1 @'h10 {
                bits 11;
                access ro;
                hard_reset 'h0;
                doc {
                    Len1
                }
            }
            field FORMAT @'h1f {
                access ro;
                hard_reset 'h1;
                doc {
                    NTTP transport protocol version
                }
            }
            doc {
                Stores NTTP packet header fields Lock, Opc, ErrCode, Len1 and indicates version of NTTP transport protocolStores NTTP packet header fields Lock, Opc, ErrCode, Len1 and indicates version of NTTP transport protocol
            }
        }
        register cdf_observer_main_ErrorLogger_0_ErrLog1 @0x18 {
            bytes 4;
            field ERRLOG1 @'h0 {
                bits 16;
                access ro;
                hard_reset 'h0;
                doc {
                    Stores NTTP packet header field RouteId (LSBs) of the logged error
                }
            }
        }
        register cdf_observer_main_ErrorLogger_0_Reserved_00 @0x1C {
            bytes 4;
            field cdf_observer_main_ErrorLogger_0_Reserved_00 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_ErrorLogger_0_ErrLog3 @0x20 {
            bytes 4;
            field ERRLOG3 @'h0 {
                bits 30;
                access ro;
                hard_reset 'h0;
                doc {
                    Stores NTTP packet header field Addr (LSBs) of the logged error
                }
            }
        }
        register cdf_observer_main_ErrorLogger_0_Reserved_01 @0x24 {
            bytes 4;
            field cdf_observer_main_ErrorLogger_0_Reserved_01 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_ErrorLogger_0_ErrLog5 @0x28 {
            bytes 4;
            field ERRLOG5 @'h0 {
                bits 27;
                access ro;
                hard_reset 'h0;
                doc {
                    Stores NTTP packet header field User (LSBs) of the logged error
                }
            }
        }
        register cdf_observer_main_ErrorLogger_0_Reserved_02 @0x2C {
            bytes 4;
            field cdf_observer_main_ErrorLogger_0_Reserved_02 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_ErrorLogger_0_Reserved_03 @0x30 {
            bytes 4;
            field cdf_observer_main_ErrorLogger_0_Reserved_03 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_ErrorLogger_0_Reserved_04 @0x34 {
            bytes 4;
            field cdf_observer_main_ErrorLogger_0_Reserved_04 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_ErrorLogger_0_StallEn @0x38 {
            bytes 4;
            field STALLEN @'h0 {
                access rw;
                hard_reset 'h0;
                doc {
                    Set to 1 to enable stall mode behavior.
                }
            }
        }
        register cdf_observer_main_ErrorLogger_0_Reserved_05 @0x3C {
            bytes 4;
            field cdf_observer_main_ErrorLogger_0_Reserved_05 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_ErrorLogger_0_Reserved_06 @0x40 {
            bytes 4;
            field cdf_observer_main_ErrorLogger_0_Reserved_06 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_ErrorLogger_0_Reserved_07 @0x44 {
            bytes 4;
            field cdf_observer_main_ErrorLogger_0_Reserved_07 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_ErrorLogger_0_Reserved_08 @0x48 {
            bytes 4;
            field cdf_observer_main_ErrorLogger_0_Reserved_08 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_ErrorLogger_0_Reserved_09 @0x4C {
            bytes 4;
            field cdf_observer_main_ErrorLogger_0_Reserved_09 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_ErrorLogger_0_Reserved_10 @0x50 {
            bytes 4;
            field cdf_observer_main_ErrorLogger_0_Reserved_10 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_ErrorLogger_0_Reserved_11 @0x54 {
            bytes 4;
            field cdf_observer_main_ErrorLogger_0_Reserved_11 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_ErrorLogger_0_Reserved_12 @0x58 {
            bytes 4;
            field cdf_observer_main_ErrorLogger_0_Reserved_12 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_ErrorLogger_0_Reserved_13 @0x5C {
            bytes 4;
            field cdf_observer_main_ErrorLogger_0_Reserved_13 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_ErrorLogger_0_Reserved_14 @0x60 {
            bytes 4;
            field cdf_observer_main_ErrorLogger_0_Reserved_14 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_ErrorLogger_0_Reserved_15 @0x64 {
            bytes 4;
            field cdf_observer_main_ErrorLogger_0_Reserved_15 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_ErrorLogger_0_Reserved_16 @0x68 {
            bytes 4;
            field cdf_observer_main_ErrorLogger_0_Reserved_16 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_ErrorLogger_0_Reserved_17 @0x6C {
            bytes 4;
            field cdf_observer_main_ErrorLogger_0_Reserved_17 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_ErrorLogger_0_Reserved_18 @0x70 {
            bytes 4;
            field cdf_observer_main_ErrorLogger_0_Reserved_18 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_ErrorLogger_0_Reserved_19 @0x74 {
            bytes 4;
            field cdf_observer_main_ErrorLogger_0_Reserved_19 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_ErrorLogger_0_Reserved_20 @0x78 {
            bytes 4;
            field cdf_observer_main_ErrorLogger_0_Reserved_20 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdf_observer_main_ErrorLogger_0_Reserved_21 @0x7C {
            bytes 4;
            field cdf_observer_main_ErrorLogger_0_Reserved_21 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
    }
    block cdma0_cdf_axi_I_main_QosGenerator @0x7800 {
        bytes 4;
        register cdma0_cdf_axi_I_main_QosGenerator_Id_CoreId @0x0 {
            bytes 4;
            field CORETYPEID @'h0 {
                bits 8;
                access ro;
                hard_reset 'h4;
                doc {
                    Field identifying the type of IP.
                }
            }
            field CORECHECKSUM @'h8 {
                bits 24;
                access ro;
                hard_reset 'hf84ebf;
                doc {
                    Field containing a checksum of the parameters of the IP.
                }
            }
        }
        register cdma0_cdf_axi_I_main_QosGenerator_Id_RevisionId @0x4 {
            bytes 4;
            field USERID @'h0 {
                bits 8;
                access ro;
                hard_reset 'h0;
                doc {
                    Field containing a user defined value, not used anywhere inside the IP itself.
                }
            }
            field FLEXNOCID @'h8 {
                bits 24;
                access ro;
                hard_reset 'h84f8c6;
                doc {
                    Field containing the build revision of the software used to generate the IP HDL code.
                }
            }
        }
        register cdma0_cdf_axi_I_main_QosGenerator_Priority @0x8 {
            bytes 4;
            field P0 @'h0 {
                bits 3;
                access rw;
                hard_reset 'h0;
                doc {
                    In Regulator mode, defines the LOW hurry level. In Fixed/Limiter mode, defines the Urgency level for WRITE transactions.
                }
            }
            field P1 @'h8 {
                bits 3;
                access rw;
                hard_reset 'h0;
                doc {
                    In Regulator mode, defines the HIGH hurry level. In Fixed/Limiter mode, defines the Urgency level for READ transactions.
                }
            }
            field MARK @'h1f {
                access ro;
                hard_reset 'h1;
                doc {
                    Backward compatibility marker when 0.
                }
            }
            doc {
                Priority register.Priority register.
            }
        }
        register cdma0_cdf_axi_I_main_QosGenerator_Mode @0xC {
            bytes 4;
            field MODE @'h0 {
                bits 2;
                access rw;
                hard_reset 'h3;
                doc {
                    Functional Mode: 0=Fixed, 1=Limiter, 2=Bypass, 3=Regulator.
                }
            }
        }
        register cdma0_cdf_axi_I_main_QosGenerator_Bandwidth @0x10 {
            bytes 4;
            field BANDWIDTH @'h0 {
                bits 16;
                access rw;
                hard_reset 'h5ed0;
                doc {
                    Defines the bandwidth threshold in 1/256th-byte-per-cycle units. In other words, the desired rate in MBps is divided by frequency in MHz of the NIU, and then multiplied by 256.
                }
            }
        }
        register cdma0_cdf_axi_I_main_QosGenerator_Saturation @0x14 {
            bytes 4;
            field SATURATION @'h0 {
                bits 10;
                access rw;
                hard_reset 'h8;
                doc {
                    Defines the size of the bandwidth counter, that is, the measurement window, in 16-byte units. In other words, the desired number of bytes divided by 16.
                }
            }
        }
        register cdma0_cdf_axi_I_main_QosGenerator_ExtControl @0x18 {
            bytes 4;
            field SOCKETQOSEN @'h0 {
                access rw;
                hard_reset 'h0;
                doc {
                    Register field SocketQosEn determines how priority levels are driven when QoS generators and socket interfaces alternatively drive the levels for Urgency, Pressure, and Hurry signals: When set to 0, the QoS generator drives the levels. When set to 1, internal signals Pressure and Hurry are driven by the greater of the two levels from the socket interface or the QoS generator.
                }
            }
            field EXTTHREN @'h1 {
                access rw;
                hard_reset 'h0;
                doc {
                    When register field ExtThrEn is set, internal signals Urgency, Press and Hurry are driven, when input signal ExtThr is low, by the value in register Priority field P0. When ExtThr is high, they are drven by the value in register Priority field P1.
                }
            }
            field INTCLKEN @'h2 {
                access rw;
                hard_reset 'h0;
                doc {
                    When set to 1, register field IntClkEn causes the QoS generator to use the NIU clock for bandwidth calculation. When set to 0, and if configuration parameter useExternalReference is set to True, an external reference clock at the socket is used for bandwidth calculation.
                }
            }
            field EXTLIMITEN @'h3 {
                access rw;
                hard_reset 'h0;
                doc {
                    When register field ExtLimitEn is set, the bandwidth limiter is enabled when input signal ExtThr is asserted. When the signal is not asserted, the limiter is disabled: bandwidth is not limited, and the counter is stuck to 0. When the bit is cleared, the limiter operates normally and ignores ExtThr.
                }
            }
            doc {
                External inputs control.External inputs control.
            }
        }
        register cdma0_cdf_axi_I_main_QosGenerator_Reserved_00 @0x1C {
            bytes 4;
            field cdma0_cdf_axi_I_main_QosGenerator_Reserved_00 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma0_cdf_axi_I_main_QosGenerator_Reserved_01 @0x20 {
            bytes 4;
            field cdma0_cdf_axi_I_main_QosGenerator_Reserved_01 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma0_cdf_axi_I_main_QosGenerator_Reserved_02 @0x24 {
            bytes 4;
            field cdma0_cdf_axi_I_main_QosGenerator_Reserved_02 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma0_cdf_axi_I_main_QosGenerator_Reserved_03 @0x28 {
            bytes 4;
            field cdma0_cdf_axi_I_main_QosGenerator_Reserved_03 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma0_cdf_axi_I_main_QosGenerator_Reserved_04 @0x2C {
            bytes 4;
            field cdma0_cdf_axi_I_main_QosGenerator_Reserved_04 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma0_cdf_axi_I_main_QosGenerator_Reserved_05 @0x30 {
            bytes 4;
            field cdma0_cdf_axi_I_main_QosGenerator_Reserved_05 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma0_cdf_axi_I_main_QosGenerator_Reserved_06 @0x34 {
            bytes 4;
            field cdma0_cdf_axi_I_main_QosGenerator_Reserved_06 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma0_cdf_axi_I_main_QosGenerator_Reserved_07 @0x38 {
            bytes 4;
            field cdma0_cdf_axi_I_main_QosGenerator_Reserved_07 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma0_cdf_axi_I_main_QosGenerator_Reserved_08 @0x3C {
            bytes 4;
            field cdma0_cdf_axi_I_main_QosGenerator_Reserved_08 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma0_cdf_axi_I_main_QosGenerator_Reserved_09 @0x40 {
            bytes 4;
            field cdma0_cdf_axi_I_main_QosGenerator_Reserved_09 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma0_cdf_axi_I_main_QosGenerator_Reserved_10 @0x44 {
            bytes 4;
            field cdma0_cdf_axi_I_main_QosGenerator_Reserved_10 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma0_cdf_axi_I_main_QosGenerator_Reserved_11 @0x48 {
            bytes 4;
            field cdma0_cdf_axi_I_main_QosGenerator_Reserved_11 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma0_cdf_axi_I_main_QosGenerator_Reserved_12 @0x4C {
            bytes 4;
            field cdma0_cdf_axi_I_main_QosGenerator_Reserved_12 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma0_cdf_axi_I_main_QosGenerator_Reserved_13 @0x50 {
            bytes 4;
            field cdma0_cdf_axi_I_main_QosGenerator_Reserved_13 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma0_cdf_axi_I_main_QosGenerator_Reserved_14 @0x54 {
            bytes 4;
            field cdma0_cdf_axi_I_main_QosGenerator_Reserved_14 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma0_cdf_axi_I_main_QosGenerator_Reserved_15 @0x58 {
            bytes 4;
            field cdma0_cdf_axi_I_main_QosGenerator_Reserved_15 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma0_cdf_axi_I_main_QosGenerator_Reserved_16 @0x5C {
            bytes 4;
            field cdma0_cdf_axi_I_main_QosGenerator_Reserved_16 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma0_cdf_axi_I_main_QosGenerator_Reserved_17 @0x60 {
            bytes 4;
            field cdma0_cdf_axi_I_main_QosGenerator_Reserved_17 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma0_cdf_axi_I_main_QosGenerator_Reserved_18 @0x64 {
            bytes 4;
            field cdma0_cdf_axi_I_main_QosGenerator_Reserved_18 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma0_cdf_axi_I_main_QosGenerator_Reserved_19 @0x68 {
            bytes 4;
            field cdma0_cdf_axi_I_main_QosGenerator_Reserved_19 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma0_cdf_axi_I_main_QosGenerator_Reserved_20 @0x6C {
            bytes 4;
            field cdma0_cdf_axi_I_main_QosGenerator_Reserved_20 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma0_cdf_axi_I_main_QosGenerator_Reserved_21 @0x70 {
            bytes 4;
            field cdma0_cdf_axi_I_main_QosGenerator_Reserved_21 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma0_cdf_axi_I_main_QosGenerator_Reserved_22 @0x74 {
            bytes 4;
            field cdma0_cdf_axi_I_main_QosGenerator_Reserved_22 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma0_cdf_axi_I_main_QosGenerator_Reserved_23 @0x78 {
            bytes 4;
            field cdma0_cdf_axi_I_main_QosGenerator_Reserved_23 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma0_cdf_axi_I_main_QosGenerator_Reserved_24 @0x7C {
            bytes 4;
            field cdma0_cdf_axi_I_main_QosGenerator_Reserved_24 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
    }
    block cdma1_cdf_axi_I_main_QosGenerator @0x7880 {
        bytes 4;
        register cdma1_cdf_axi_I_main_QosGenerator_Id_CoreId @0x0 {
            bytes 4;
            field CORETYPEID @'h0 {
                bits 8;
                access ro;
                hard_reset 'h4;
                doc {
                    Field identifying the type of IP.
                }
            }
            field CORECHECKSUM @'h8 {
                bits 24;
                access ro;
                hard_reset 'hab85e9;
                doc {
                    Field containing a checksum of the parameters of the IP.
                }
            }
        }
        register cdma1_cdf_axi_I_main_QosGenerator_Id_RevisionId @0x4 {
            bytes 4;
            field USERID @'h0 {
                bits 8;
                access ro;
                hard_reset 'h0;
                doc {
                    Field containing a user defined value, not used anywhere inside the IP itself.
                }
            }
            field FLEXNOCID @'h8 {
                bits 24;
                access ro;
                hard_reset 'h84f8c6;
                doc {
                    Field containing the build revision of the software used to generate the IP HDL code.
                }
            }
        }
        register cdma1_cdf_axi_I_main_QosGenerator_Priority @0x8 {
            bytes 4;
            field P0 @'h0 {
                bits 3;
                access rw;
                hard_reset 'h0;
                doc {
                    In Regulator mode, defines the LOW hurry level. In Fixed/Limiter mode, defines the Urgency level for WRITE transactions.
                }
            }
            field P1 @'h8 {
                bits 3;
                access rw;
                hard_reset 'h0;
                doc {
                    In Regulator mode, defines the HIGH hurry level. In Fixed/Limiter mode, defines the Urgency level for READ transactions.
                }
            }
            field MARK @'h1f {
                access ro;
                hard_reset 'h1;
                doc {
                    Backward compatibility marker when 0.
                }
            }
            doc {
                Priority register.Priority register.
            }
        }
        register cdma1_cdf_axi_I_main_QosGenerator_Mode @0xC {
            bytes 4;
            field MODE @'h0 {
                bits 2;
                access rw;
                hard_reset 'h3;
                doc {
                    Functional Mode: 0=Fixed, 1=Limiter, 2=Bypass, 3=Regulator.
                }
            }
        }
        register cdma1_cdf_axi_I_main_QosGenerator_Bandwidth @0x10 {
            bytes 4;
            field BANDWIDTH @'h0 {
                bits 16;
                access rw;
                hard_reset 'h5ed0;
                doc {
                    Defines the bandwidth threshold in 1/256th-byte-per-cycle units. In other words, the desired rate in MBps is divided by frequency in MHz of the NIU, and then multiplied by 256.
                }
            }
        }
        register cdma1_cdf_axi_I_main_QosGenerator_Saturation @0x14 {
            bytes 4;
            field SATURATION @'h0 {
                bits 10;
                access rw;
                hard_reset 'h8;
                doc {
                    Defines the size of the bandwidth counter, that is, the measurement window, in 16-byte units. In other words, the desired number of bytes divided by 16.
                }
            }
        }
        register cdma1_cdf_axi_I_main_QosGenerator_ExtControl @0x18 {
            bytes 4;
            field SOCKETQOSEN @'h0 {
                access rw;
                hard_reset 'h0;
                doc {
                    Register field SocketQosEn determines how priority levels are driven when QoS generators and socket interfaces alternatively drive the levels for Urgency, Pressure, and Hurry signals: When set to 0, the QoS generator drives the levels. When set to 1, internal signals Pressure and Hurry are driven by the greater of the two levels from the socket interface or the QoS generator.
                }
            }
            field EXTTHREN @'h1 {
                access rw;
                hard_reset 'h0;
                doc {
                    When register field ExtThrEn is set, internal signals Urgency, Press and Hurry are driven, when input signal ExtThr is low, by the value in register Priority field P0. When ExtThr is high, they are drven by the value in register Priority field P1.
                }
            }
            field INTCLKEN @'h2 {
                access rw;
                hard_reset 'h0;
                doc {
                    When set to 1, register field IntClkEn causes the QoS generator to use the NIU clock for bandwidth calculation. When set to 0, and if configuration parameter useExternalReference is set to True, an external reference clock at the socket is used for bandwidth calculation.
                }
            }
            field EXTLIMITEN @'h3 {
                access rw;
                hard_reset 'h0;
                doc {
                    When register field ExtLimitEn is set, the bandwidth limiter is enabled when input signal ExtThr is asserted. When the signal is not asserted, the limiter is disabled: bandwidth is not limited, and the counter is stuck to 0. When the bit is cleared, the limiter operates normally and ignores ExtThr.
                }
            }
            doc {
                External inputs control.External inputs control.
            }
        }
        register cdma1_cdf_axi_I_main_QosGenerator_Reserved_00 @0x1C {
            bytes 4;
            field cdma1_cdf_axi_I_main_QosGenerator_Reserved_00 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma1_cdf_axi_I_main_QosGenerator_Reserved_01 @0x20 {
            bytes 4;
            field cdma1_cdf_axi_I_main_QosGenerator_Reserved_01 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma1_cdf_axi_I_main_QosGenerator_Reserved_02 @0x24 {
            bytes 4;
            field cdma1_cdf_axi_I_main_QosGenerator_Reserved_02 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma1_cdf_axi_I_main_QosGenerator_Reserved_03 @0x28 {
            bytes 4;
            field cdma1_cdf_axi_I_main_QosGenerator_Reserved_03 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma1_cdf_axi_I_main_QosGenerator_Reserved_04 @0x2C {
            bytes 4;
            field cdma1_cdf_axi_I_main_QosGenerator_Reserved_04 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma1_cdf_axi_I_main_QosGenerator_Reserved_05 @0x30 {
            bytes 4;
            field cdma1_cdf_axi_I_main_QosGenerator_Reserved_05 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma1_cdf_axi_I_main_QosGenerator_Reserved_06 @0x34 {
            bytes 4;
            field cdma1_cdf_axi_I_main_QosGenerator_Reserved_06 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma1_cdf_axi_I_main_QosGenerator_Reserved_07 @0x38 {
            bytes 4;
            field cdma1_cdf_axi_I_main_QosGenerator_Reserved_07 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma1_cdf_axi_I_main_QosGenerator_Reserved_08 @0x3C {
            bytes 4;
            field cdma1_cdf_axi_I_main_QosGenerator_Reserved_08 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma1_cdf_axi_I_main_QosGenerator_Reserved_09 @0x40 {
            bytes 4;
            field cdma1_cdf_axi_I_main_QosGenerator_Reserved_09 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma1_cdf_axi_I_main_QosGenerator_Reserved_10 @0x44 {
            bytes 4;
            field cdma1_cdf_axi_I_main_QosGenerator_Reserved_10 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma1_cdf_axi_I_main_QosGenerator_Reserved_11 @0x48 {
            bytes 4;
            field cdma1_cdf_axi_I_main_QosGenerator_Reserved_11 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma1_cdf_axi_I_main_QosGenerator_Reserved_12 @0x4C {
            bytes 4;
            field cdma1_cdf_axi_I_main_QosGenerator_Reserved_12 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma1_cdf_axi_I_main_QosGenerator_Reserved_13 @0x50 {
            bytes 4;
            field cdma1_cdf_axi_I_main_QosGenerator_Reserved_13 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma1_cdf_axi_I_main_QosGenerator_Reserved_14 @0x54 {
            bytes 4;
            field cdma1_cdf_axi_I_main_QosGenerator_Reserved_14 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma1_cdf_axi_I_main_QosGenerator_Reserved_15 @0x58 {
            bytes 4;
            field cdma1_cdf_axi_I_main_QosGenerator_Reserved_15 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma1_cdf_axi_I_main_QosGenerator_Reserved_16 @0x5C {
            bytes 4;
            field cdma1_cdf_axi_I_main_QosGenerator_Reserved_16 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma1_cdf_axi_I_main_QosGenerator_Reserved_17 @0x60 {
            bytes 4;
            field cdma1_cdf_axi_I_main_QosGenerator_Reserved_17 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma1_cdf_axi_I_main_QosGenerator_Reserved_18 @0x64 {
            bytes 4;
            field cdma1_cdf_axi_I_main_QosGenerator_Reserved_18 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma1_cdf_axi_I_main_QosGenerator_Reserved_19 @0x68 {
            bytes 4;
            field cdma1_cdf_axi_I_main_QosGenerator_Reserved_19 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma1_cdf_axi_I_main_QosGenerator_Reserved_20 @0x6C {
            bytes 4;
            field cdma1_cdf_axi_I_main_QosGenerator_Reserved_20 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma1_cdf_axi_I_main_QosGenerator_Reserved_21 @0x70 {
            bytes 4;
            field cdma1_cdf_axi_I_main_QosGenerator_Reserved_21 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma1_cdf_axi_I_main_QosGenerator_Reserved_22 @0x74 {
            bytes 4;
            field cdma1_cdf_axi_I_main_QosGenerator_Reserved_22 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma1_cdf_axi_I_main_QosGenerator_Reserved_23 @0x78 {
            bytes 4;
            field cdma1_cdf_axi_I_main_QosGenerator_Reserved_23 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register cdma1_cdf_axi_I_main_QosGenerator_Reserved_24 @0x7C {
            bytes 4;
            field cdma1_cdf_axi_I_main_QosGenerator_Reserved_24 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
    }
    block sip0_cdf_axi_I_main_QosGenerator @0x7900 {
        bytes 4;
        register sip0_cdf_axi_I_main_QosGenerator_Id_CoreId @0x0 {
            bytes 4;
            field CORETYPEID @'h0 {
                bits 8;
                access ro;
                hard_reset 'h4;
                doc {
                    Field identifying the type of IP.
                }
            }
            field CORECHECKSUM @'h8 {
                bits 24;
                access ro;
                hard_reset 'h49cd99;
                doc {
                    Field containing a checksum of the parameters of the IP.
                }
            }
        }
        register sip0_cdf_axi_I_main_QosGenerator_Id_RevisionId @0x4 {
            bytes 4;
            field USERID @'h0 {
                bits 8;
                access ro;
                hard_reset 'h0;
                doc {
                    Field containing a user defined value, not used anywhere inside the IP itself.
                }
            }
            field FLEXNOCID @'h8 {
                bits 24;
                access ro;
                hard_reset 'h84f8c6;
                doc {
                    Field containing the build revision of the software used to generate the IP HDL code.
                }
            }
        }
        register sip0_cdf_axi_I_main_QosGenerator_Priority @0x8 {
            bytes 4;
            field P0 @'h0 {
                bits 3;
                access rw;
                hard_reset 'h0;
                doc {
                    In Regulator mode, defines the LOW hurry level. In Fixed/Limiter mode, defines the Urgency level for WRITE transactions.
                }
            }
            field P1 @'h8 {
                bits 3;
                access rw;
                hard_reset 'h0;
                doc {
                    In Regulator mode, defines the HIGH hurry level. In Fixed/Limiter mode, defines the Urgency level for READ transactions.
                }
            }
            field MARK @'h1f {
                access ro;
                hard_reset 'h1;
                doc {
                    Backward compatibility marker when 0.
                }
            }
            doc {
                Priority register.Priority register.
            }
        }
        register sip0_cdf_axi_I_main_QosGenerator_Mode @0xC {
            bytes 4;
            field MODE @'h0 {
                bits 2;
                access rw;
                hard_reset 'h3;
                doc {
                    Functional Mode: 0=Fixed, 1=Limiter, 2=Bypass, 3=Regulator.
                }
            }
        }
        register sip0_cdf_axi_I_main_QosGenerator_Bandwidth @0x10 {
            bytes 4;
            field BANDWIDTH @'h0 {
                bits 16;
                access rw;
                hard_reset 'h5ed0;
                doc {
                    Defines the bandwidth threshold in 1/256th-byte-per-cycle units. In other words, the desired rate in MBps is divided by frequency in MHz of the NIU, and then multiplied by 256.
                }
            }
        }
        register sip0_cdf_axi_I_main_QosGenerator_Saturation @0x14 {
            bytes 4;
            field SATURATION @'h0 {
                bits 10;
                access rw;
                hard_reset 'h8;
                doc {
                    Defines the size of the bandwidth counter, that is, the measurement window, in 16-byte units. In other words, the desired number of bytes divided by 16.
                }
            }
        }
        register sip0_cdf_axi_I_main_QosGenerator_ExtControl @0x18 {
            bytes 4;
            field SOCKETQOSEN @'h0 {
                access rw;
                hard_reset 'h0;
                doc {
                    Register field SocketQosEn determines how priority levels are driven when QoS generators and socket interfaces alternatively drive the levels for Urgency, Pressure, and Hurry signals: When set to 0, the QoS generator drives the levels. When set to 1, internal signals Pressure and Hurry are driven by the greater of the two levels from the socket interface or the QoS generator.
                }
            }
            field EXTTHREN @'h1 {
                access rw;
                hard_reset 'h0;
                doc {
                    When register field ExtThrEn is set, internal signals Urgency, Press and Hurry are driven, when input signal ExtThr is low, by the value in register Priority field P0. When ExtThr is high, they are drven by the value in register Priority field P1.
                }
            }
            field INTCLKEN @'h2 {
                access rw;
                hard_reset 'h0;
                doc {
                    When set to 1, register field IntClkEn causes the QoS generator to use the NIU clock for bandwidth calculation. When set to 0, and if configuration parameter useExternalReference is set to True, an external reference clock at the socket is used for bandwidth calculation.
                }
            }
            field EXTLIMITEN @'h3 {
                access rw;
                hard_reset 'h0;
                doc {
                    When register field ExtLimitEn is set, the bandwidth limiter is enabled when input signal ExtThr is asserted. When the signal is not asserted, the limiter is disabled: bandwidth is not limited, and the counter is stuck to 0. When the bit is cleared, the limiter operates normally and ignores ExtThr.
                }
            }
            doc {
                External inputs control.External inputs control.
            }
        }
        register sip0_cdf_axi_I_main_QosGenerator_Reserved_00 @0x1C {
            bytes 4;
            field sip0_cdf_axi_I_main_QosGenerator_Reserved_00 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip0_cdf_axi_I_main_QosGenerator_Reserved_01 @0x20 {
            bytes 4;
            field sip0_cdf_axi_I_main_QosGenerator_Reserved_01 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip0_cdf_axi_I_main_QosGenerator_Reserved_02 @0x24 {
            bytes 4;
            field sip0_cdf_axi_I_main_QosGenerator_Reserved_02 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip0_cdf_axi_I_main_QosGenerator_Reserved_03 @0x28 {
            bytes 4;
            field sip0_cdf_axi_I_main_QosGenerator_Reserved_03 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip0_cdf_axi_I_main_QosGenerator_Reserved_04 @0x2C {
            bytes 4;
            field sip0_cdf_axi_I_main_QosGenerator_Reserved_04 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip0_cdf_axi_I_main_QosGenerator_Reserved_05 @0x30 {
            bytes 4;
            field sip0_cdf_axi_I_main_QosGenerator_Reserved_05 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip0_cdf_axi_I_main_QosGenerator_Reserved_06 @0x34 {
            bytes 4;
            field sip0_cdf_axi_I_main_QosGenerator_Reserved_06 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip0_cdf_axi_I_main_QosGenerator_Reserved_07 @0x38 {
            bytes 4;
            field sip0_cdf_axi_I_main_QosGenerator_Reserved_07 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip0_cdf_axi_I_main_QosGenerator_Reserved_08 @0x3C {
            bytes 4;
            field sip0_cdf_axi_I_main_QosGenerator_Reserved_08 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip0_cdf_axi_I_main_QosGenerator_Reserved_09 @0x40 {
            bytes 4;
            field sip0_cdf_axi_I_main_QosGenerator_Reserved_09 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip0_cdf_axi_I_main_QosGenerator_Reserved_10 @0x44 {
            bytes 4;
            field sip0_cdf_axi_I_main_QosGenerator_Reserved_10 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip0_cdf_axi_I_main_QosGenerator_Reserved_11 @0x48 {
            bytes 4;
            field sip0_cdf_axi_I_main_QosGenerator_Reserved_11 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip0_cdf_axi_I_main_QosGenerator_Reserved_12 @0x4C {
            bytes 4;
            field sip0_cdf_axi_I_main_QosGenerator_Reserved_12 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip0_cdf_axi_I_main_QosGenerator_Reserved_13 @0x50 {
            bytes 4;
            field sip0_cdf_axi_I_main_QosGenerator_Reserved_13 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip0_cdf_axi_I_main_QosGenerator_Reserved_14 @0x54 {
            bytes 4;
            field sip0_cdf_axi_I_main_QosGenerator_Reserved_14 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip0_cdf_axi_I_main_QosGenerator_Reserved_15 @0x58 {
            bytes 4;
            field sip0_cdf_axi_I_main_QosGenerator_Reserved_15 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip0_cdf_axi_I_main_QosGenerator_Reserved_16 @0x5C {
            bytes 4;
            field sip0_cdf_axi_I_main_QosGenerator_Reserved_16 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip0_cdf_axi_I_main_QosGenerator_Reserved_17 @0x60 {
            bytes 4;
            field sip0_cdf_axi_I_main_QosGenerator_Reserved_17 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip0_cdf_axi_I_main_QosGenerator_Reserved_18 @0x64 {
            bytes 4;
            field sip0_cdf_axi_I_main_QosGenerator_Reserved_18 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip0_cdf_axi_I_main_QosGenerator_Reserved_19 @0x68 {
            bytes 4;
            field sip0_cdf_axi_I_main_QosGenerator_Reserved_19 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip0_cdf_axi_I_main_QosGenerator_Reserved_20 @0x6C {
            bytes 4;
            field sip0_cdf_axi_I_main_QosGenerator_Reserved_20 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip0_cdf_axi_I_main_QosGenerator_Reserved_21 @0x70 {
            bytes 4;
            field sip0_cdf_axi_I_main_QosGenerator_Reserved_21 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip0_cdf_axi_I_main_QosGenerator_Reserved_22 @0x74 {
            bytes 4;
            field sip0_cdf_axi_I_main_QosGenerator_Reserved_22 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip0_cdf_axi_I_main_QosGenerator_Reserved_23 @0x78 {
            bytes 4;
            field sip0_cdf_axi_I_main_QosGenerator_Reserved_23 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip0_cdf_axi_I_main_QosGenerator_Reserved_24 @0x7C {
            bytes 4;
            field sip0_cdf_axi_I_main_QosGenerator_Reserved_24 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
    }
    block sip1_cdf_axi_I_main_QosGenerator @0x7980 {
        bytes 4;
        register sip1_cdf_axi_I_main_QosGenerator_Id_CoreId @0x0 {
            bytes 4;
            field CORETYPEID @'h0 {
                bits 8;
                access ro;
                hard_reset 'h4;
                doc {
                    Field identifying the type of IP.
                }
            }
            field CORECHECKSUM @'h8 {
                bits 24;
                access ro;
                hard_reset 'hf84864;
                doc {
                    Field containing a checksum of the parameters of the IP.
                }
            }
        }
        register sip1_cdf_axi_I_main_QosGenerator_Id_RevisionId @0x4 {
            bytes 4;
            field USERID @'h0 {
                bits 8;
                access ro;
                hard_reset 'h0;
                doc {
                    Field containing a user defined value, not used anywhere inside the IP itself.
                }
            }
            field FLEXNOCID @'h8 {
                bits 24;
                access ro;
                hard_reset 'h84f8c6;
                doc {
                    Field containing the build revision of the software used to generate the IP HDL code.
                }
            }
        }
        register sip1_cdf_axi_I_main_QosGenerator_Priority @0x8 {
            bytes 4;
            field P0 @'h0 {
                bits 3;
                access rw;
                hard_reset 'h0;
                doc {
                    In Regulator mode, defines the LOW hurry level. In Fixed/Limiter mode, defines the Urgency level for WRITE transactions.
                }
            }
            field P1 @'h8 {
                bits 3;
                access rw;
                hard_reset 'h0;
                doc {
                    In Regulator mode, defines the HIGH hurry level. In Fixed/Limiter mode, defines the Urgency level for READ transactions.
                }
            }
            field MARK @'h1f {
                access ro;
                hard_reset 'h1;
                doc {
                    Backward compatibility marker when 0.
                }
            }
            doc {
                Priority register.Priority register.
            }
        }
        register sip1_cdf_axi_I_main_QosGenerator_Mode @0xC {
            bytes 4;
            field MODE @'h0 {
                bits 2;
                access rw;
                hard_reset 'h3;
                doc {
                    Functional Mode: 0=Fixed, 1=Limiter, 2=Bypass, 3=Regulator.
                }
            }
        }
        register sip1_cdf_axi_I_main_QosGenerator_Bandwidth @0x10 {
            bytes 4;
            field BANDWIDTH @'h0 {
                bits 16;
                access rw;
                hard_reset 'h5ed0;
                doc {
                    Defines the bandwidth threshold in 1/256th-byte-per-cycle units. In other words, the desired rate in MBps is divided by frequency in MHz of the NIU, and then multiplied by 256.
                }
            }
        }
        register sip1_cdf_axi_I_main_QosGenerator_Saturation @0x14 {
            bytes 4;
            field SATURATION @'h0 {
                bits 10;
                access rw;
                hard_reset 'h8;
                doc {
                    Defines the size of the bandwidth counter, that is, the measurement window, in 16-byte units. In other words, the desired number of bytes divided by 16.
                }
            }
        }
        register sip1_cdf_axi_I_main_QosGenerator_ExtControl @0x18 {
            bytes 4;
            field SOCKETQOSEN @'h0 {
                access rw;
                hard_reset 'h0;
                doc {
                    Register field SocketQosEn determines how priority levels are driven when QoS generators and socket interfaces alternatively drive the levels for Urgency, Pressure, and Hurry signals: When set to 0, the QoS generator drives the levels. When set to 1, internal signals Pressure and Hurry are driven by the greater of the two levels from the socket interface or the QoS generator.
                }
            }
            field EXTTHREN @'h1 {
                access rw;
                hard_reset 'h0;
                doc {
                    When register field ExtThrEn is set, internal signals Urgency, Press and Hurry are driven, when input signal ExtThr is low, by the value in register Priority field P0. When ExtThr is high, they are drven by the value in register Priority field P1.
                }
            }
            field INTCLKEN @'h2 {
                access rw;
                hard_reset 'h0;
                doc {
                    When set to 1, register field IntClkEn causes the QoS generator to use the NIU clock for bandwidth calculation. When set to 0, and if configuration parameter useExternalReference is set to True, an external reference clock at the socket is used for bandwidth calculation.
                }
            }
            field EXTLIMITEN @'h3 {
                access rw;
                hard_reset 'h0;
                doc {
                    When register field ExtLimitEn is set, the bandwidth limiter is enabled when input signal ExtThr is asserted. When the signal is not asserted, the limiter is disabled: bandwidth is not limited, and the counter is stuck to 0. When the bit is cleared, the limiter operates normally and ignores ExtThr.
                }
            }
            doc {
                External inputs control.External inputs control.
            }
        }
        register sip1_cdf_axi_I_main_QosGenerator_Reserved_00 @0x1C {
            bytes 4;
            field sip1_cdf_axi_I_main_QosGenerator_Reserved_00 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip1_cdf_axi_I_main_QosGenerator_Reserved_01 @0x20 {
            bytes 4;
            field sip1_cdf_axi_I_main_QosGenerator_Reserved_01 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip1_cdf_axi_I_main_QosGenerator_Reserved_02 @0x24 {
            bytes 4;
            field sip1_cdf_axi_I_main_QosGenerator_Reserved_02 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip1_cdf_axi_I_main_QosGenerator_Reserved_03 @0x28 {
            bytes 4;
            field sip1_cdf_axi_I_main_QosGenerator_Reserved_03 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip1_cdf_axi_I_main_QosGenerator_Reserved_04 @0x2C {
            bytes 4;
            field sip1_cdf_axi_I_main_QosGenerator_Reserved_04 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip1_cdf_axi_I_main_QosGenerator_Reserved_05 @0x30 {
            bytes 4;
            field sip1_cdf_axi_I_main_QosGenerator_Reserved_05 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip1_cdf_axi_I_main_QosGenerator_Reserved_06 @0x34 {
            bytes 4;
            field sip1_cdf_axi_I_main_QosGenerator_Reserved_06 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip1_cdf_axi_I_main_QosGenerator_Reserved_07 @0x38 {
            bytes 4;
            field sip1_cdf_axi_I_main_QosGenerator_Reserved_07 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip1_cdf_axi_I_main_QosGenerator_Reserved_08 @0x3C {
            bytes 4;
            field sip1_cdf_axi_I_main_QosGenerator_Reserved_08 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip1_cdf_axi_I_main_QosGenerator_Reserved_09 @0x40 {
            bytes 4;
            field sip1_cdf_axi_I_main_QosGenerator_Reserved_09 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip1_cdf_axi_I_main_QosGenerator_Reserved_10 @0x44 {
            bytes 4;
            field sip1_cdf_axi_I_main_QosGenerator_Reserved_10 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip1_cdf_axi_I_main_QosGenerator_Reserved_11 @0x48 {
            bytes 4;
            field sip1_cdf_axi_I_main_QosGenerator_Reserved_11 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip1_cdf_axi_I_main_QosGenerator_Reserved_12 @0x4C {
            bytes 4;
            field sip1_cdf_axi_I_main_QosGenerator_Reserved_12 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip1_cdf_axi_I_main_QosGenerator_Reserved_13 @0x50 {
            bytes 4;
            field sip1_cdf_axi_I_main_QosGenerator_Reserved_13 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip1_cdf_axi_I_main_QosGenerator_Reserved_14 @0x54 {
            bytes 4;
            field sip1_cdf_axi_I_main_QosGenerator_Reserved_14 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip1_cdf_axi_I_main_QosGenerator_Reserved_15 @0x58 {
            bytes 4;
            field sip1_cdf_axi_I_main_QosGenerator_Reserved_15 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip1_cdf_axi_I_main_QosGenerator_Reserved_16 @0x5C {
            bytes 4;
            field sip1_cdf_axi_I_main_QosGenerator_Reserved_16 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip1_cdf_axi_I_main_QosGenerator_Reserved_17 @0x60 {
            bytes 4;
            field sip1_cdf_axi_I_main_QosGenerator_Reserved_17 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip1_cdf_axi_I_main_QosGenerator_Reserved_18 @0x64 {
            bytes 4;
            field sip1_cdf_axi_I_main_QosGenerator_Reserved_18 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip1_cdf_axi_I_main_QosGenerator_Reserved_19 @0x68 {
            bytes 4;
            field sip1_cdf_axi_I_main_QosGenerator_Reserved_19 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip1_cdf_axi_I_main_QosGenerator_Reserved_20 @0x6C {
            bytes 4;
            field sip1_cdf_axi_I_main_QosGenerator_Reserved_20 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip1_cdf_axi_I_main_QosGenerator_Reserved_21 @0x70 {
            bytes 4;
            field sip1_cdf_axi_I_main_QosGenerator_Reserved_21 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip1_cdf_axi_I_main_QosGenerator_Reserved_22 @0x74 {
            bytes 4;
            field sip1_cdf_axi_I_main_QosGenerator_Reserved_22 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip1_cdf_axi_I_main_QosGenerator_Reserved_23 @0x78 {
            bytes 4;
            field sip1_cdf_axi_I_main_QosGenerator_Reserved_23 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip1_cdf_axi_I_main_QosGenerator_Reserved_24 @0x7C {
            bytes 4;
            field sip1_cdf_axi_I_main_QosGenerator_Reserved_24 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
    }
    block sip2_cdf_axi_I_main_QosGenerator @0x7A00 {
        bytes 4;
        register sip2_cdf_axi_I_main_QosGenerator_Id_CoreId @0x0 {
            bytes 4;
            field CORETYPEID @'h0 {
                bits 8;
                access ro;
                hard_reset 'h4;
                doc {
                    Field identifying the type of IP.
                }
            }
            field CORECHECKSUM @'h8 {
                bits 24;
                access ro;
                hard_reset 'h783ba7;
                doc {
                    Field containing a checksum of the parameters of the IP.
                }
            }
        }
        register sip2_cdf_axi_I_main_QosGenerator_Id_RevisionId @0x4 {
            bytes 4;
            field USERID @'h0 {
                bits 8;
                access ro;
                hard_reset 'h0;
                doc {
                    Field containing a user defined value, not used anywhere inside the IP itself.
                }
            }
            field FLEXNOCID @'h8 {
                bits 24;
                access ro;
                hard_reset 'h84f8c6;
                doc {
                    Field containing the build revision of the software used to generate the IP HDL code.
                }
            }
        }
        register sip2_cdf_axi_I_main_QosGenerator_Priority @0x8 {
            bytes 4;
            field P0 @'h0 {
                bits 3;
                access rw;
                hard_reset 'h0;
                doc {
                    In Regulator mode, defines the LOW hurry level. In Fixed/Limiter mode, defines the Urgency level for WRITE transactions.
                }
            }
            field P1 @'h8 {
                bits 3;
                access rw;
                hard_reset 'h0;
                doc {
                    In Regulator mode, defines the HIGH hurry level. In Fixed/Limiter mode, defines the Urgency level for READ transactions.
                }
            }
            field MARK @'h1f {
                access ro;
                hard_reset 'h1;
                doc {
                    Backward compatibility marker when 0.
                }
            }
            doc {
                Priority register.Priority register.
            }
        }
        register sip2_cdf_axi_I_main_QosGenerator_Mode @0xC {
            bytes 4;
            field MODE @'h0 {
                bits 2;
                access rw;
                hard_reset 'h3;
                doc {
                    Functional Mode: 0=Fixed, 1=Limiter, 2=Bypass, 3=Regulator.
                }
            }
        }
        register sip2_cdf_axi_I_main_QosGenerator_Bandwidth @0x10 {
            bytes 4;
            field BANDWIDTH @'h0 {
                bits 16;
                access rw;
                hard_reset 'h5ed0;
                doc {
                    Defines the bandwidth threshold in 1/256th-byte-per-cycle units. In other words, the desired rate in MBps is divided by frequency in MHz of the NIU, and then multiplied by 256.
                }
            }
        }
        register sip2_cdf_axi_I_main_QosGenerator_Saturation @0x14 {
            bytes 4;
            field SATURATION @'h0 {
                bits 10;
                access rw;
                hard_reset 'h8;
                doc {
                    Defines the size of the bandwidth counter, that is, the measurement window, in 16-byte units. In other words, the desired number of bytes divided by 16.
                }
            }
        }
        register sip2_cdf_axi_I_main_QosGenerator_ExtControl @0x18 {
            bytes 4;
            field SOCKETQOSEN @'h0 {
                access rw;
                hard_reset 'h0;
                doc {
                    Register field SocketQosEn determines how priority levels are driven when QoS generators and socket interfaces alternatively drive the levels for Urgency, Pressure, and Hurry signals: When set to 0, the QoS generator drives the levels. When set to 1, internal signals Pressure and Hurry are driven by the greater of the two levels from the socket interface or the QoS generator.
                }
            }
            field EXTTHREN @'h1 {
                access rw;
                hard_reset 'h0;
                doc {
                    When register field ExtThrEn is set, internal signals Urgency, Press and Hurry are driven, when input signal ExtThr is low, by the value in register Priority field P0. When ExtThr is high, they are drven by the value in register Priority field P1.
                }
            }
            field INTCLKEN @'h2 {
                access rw;
                hard_reset 'h0;
                doc {
                    When set to 1, register field IntClkEn causes the QoS generator to use the NIU clock for bandwidth calculation. When set to 0, and if configuration parameter useExternalReference is set to True, an external reference clock at the socket is used for bandwidth calculation.
                }
            }
            field EXTLIMITEN @'h3 {
                access rw;
                hard_reset 'h0;
                doc {
                    When register field ExtLimitEn is set, the bandwidth limiter is enabled when input signal ExtThr is asserted. When the signal is not asserted, the limiter is disabled: bandwidth is not limited, and the counter is stuck to 0. When the bit is cleared, the limiter operates normally and ignores ExtThr.
                }
            }
            doc {
                External inputs control.External inputs control.
            }
        }
        register sip2_cdf_axi_I_main_QosGenerator_Reserved_00 @0x1C {
            bytes 4;
            field sip2_cdf_axi_I_main_QosGenerator_Reserved_00 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip2_cdf_axi_I_main_QosGenerator_Reserved_01 @0x20 {
            bytes 4;
            field sip2_cdf_axi_I_main_QosGenerator_Reserved_01 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip2_cdf_axi_I_main_QosGenerator_Reserved_02 @0x24 {
            bytes 4;
            field sip2_cdf_axi_I_main_QosGenerator_Reserved_02 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip2_cdf_axi_I_main_QosGenerator_Reserved_03 @0x28 {
            bytes 4;
            field sip2_cdf_axi_I_main_QosGenerator_Reserved_03 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip2_cdf_axi_I_main_QosGenerator_Reserved_04 @0x2C {
            bytes 4;
            field sip2_cdf_axi_I_main_QosGenerator_Reserved_04 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip2_cdf_axi_I_main_QosGenerator_Reserved_05 @0x30 {
            bytes 4;
            field sip2_cdf_axi_I_main_QosGenerator_Reserved_05 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip2_cdf_axi_I_main_QosGenerator_Reserved_06 @0x34 {
            bytes 4;
            field sip2_cdf_axi_I_main_QosGenerator_Reserved_06 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip2_cdf_axi_I_main_QosGenerator_Reserved_07 @0x38 {
            bytes 4;
            field sip2_cdf_axi_I_main_QosGenerator_Reserved_07 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip2_cdf_axi_I_main_QosGenerator_Reserved_08 @0x3C {
            bytes 4;
            field sip2_cdf_axi_I_main_QosGenerator_Reserved_08 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip2_cdf_axi_I_main_QosGenerator_Reserved_09 @0x40 {
            bytes 4;
            field sip2_cdf_axi_I_main_QosGenerator_Reserved_09 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip2_cdf_axi_I_main_QosGenerator_Reserved_10 @0x44 {
            bytes 4;
            field sip2_cdf_axi_I_main_QosGenerator_Reserved_10 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip2_cdf_axi_I_main_QosGenerator_Reserved_11 @0x48 {
            bytes 4;
            field sip2_cdf_axi_I_main_QosGenerator_Reserved_11 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip2_cdf_axi_I_main_QosGenerator_Reserved_12 @0x4C {
            bytes 4;
            field sip2_cdf_axi_I_main_QosGenerator_Reserved_12 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip2_cdf_axi_I_main_QosGenerator_Reserved_13 @0x50 {
            bytes 4;
            field sip2_cdf_axi_I_main_QosGenerator_Reserved_13 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip2_cdf_axi_I_main_QosGenerator_Reserved_14 @0x54 {
            bytes 4;
            field sip2_cdf_axi_I_main_QosGenerator_Reserved_14 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip2_cdf_axi_I_main_QosGenerator_Reserved_15 @0x58 {
            bytes 4;
            field sip2_cdf_axi_I_main_QosGenerator_Reserved_15 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip2_cdf_axi_I_main_QosGenerator_Reserved_16 @0x5C {
            bytes 4;
            field sip2_cdf_axi_I_main_QosGenerator_Reserved_16 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip2_cdf_axi_I_main_QosGenerator_Reserved_17 @0x60 {
            bytes 4;
            field sip2_cdf_axi_I_main_QosGenerator_Reserved_17 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip2_cdf_axi_I_main_QosGenerator_Reserved_18 @0x64 {
            bytes 4;
            field sip2_cdf_axi_I_main_QosGenerator_Reserved_18 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip2_cdf_axi_I_main_QosGenerator_Reserved_19 @0x68 {
            bytes 4;
            field sip2_cdf_axi_I_main_QosGenerator_Reserved_19 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip2_cdf_axi_I_main_QosGenerator_Reserved_20 @0x6C {
            bytes 4;
            field sip2_cdf_axi_I_main_QosGenerator_Reserved_20 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip2_cdf_axi_I_main_QosGenerator_Reserved_21 @0x70 {
            bytes 4;
            field sip2_cdf_axi_I_main_QosGenerator_Reserved_21 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip2_cdf_axi_I_main_QosGenerator_Reserved_22 @0x74 {
            bytes 4;
            field sip2_cdf_axi_I_main_QosGenerator_Reserved_22 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip2_cdf_axi_I_main_QosGenerator_Reserved_23 @0x78 {
            bytes 4;
            field sip2_cdf_axi_I_main_QosGenerator_Reserved_23 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip2_cdf_axi_I_main_QosGenerator_Reserved_24 @0x7C {
            bytes 4;
            field sip2_cdf_axi_I_main_QosGenerator_Reserved_24 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
    }
    block sip3_cdf_axi_I_main_QosGenerator @0x7A80 {
        bytes 4;
        register sip3_cdf_axi_I_main_QosGenerator_Id_CoreId @0x0 {
            bytes 4;
            field CORETYPEID @'h0 {
                bits 8;
                access ro;
                hard_reset 'h4;
                doc {
                    Field identifying the type of IP.
                }
            }
            field CORECHECKSUM @'h8 {
                bits 24;
                access ro;
                hard_reset 'h325930;
                doc {
                    Field containing a checksum of the parameters of the IP.
                }
            }
        }
        register sip3_cdf_axi_I_main_QosGenerator_Id_RevisionId @0x4 {
            bytes 4;
            field USERID @'h0 {
                bits 8;
                access ro;
                hard_reset 'h0;
                doc {
                    Field containing a user defined value, not used anywhere inside the IP itself.
                }
            }
            field FLEXNOCID @'h8 {
                bits 24;
                access ro;
                hard_reset 'h84f8c6;
                doc {
                    Field containing the build revision of the software used to generate the IP HDL code.
                }
            }
        }
        register sip3_cdf_axi_I_main_QosGenerator_Priority @0x8 {
            bytes 4;
            field P0 @'h0 {
                bits 3;
                access rw;
                hard_reset 'h0;
                doc {
                    In Regulator mode, defines the LOW hurry level. In Fixed/Limiter mode, defines the Urgency level for WRITE transactions.
                }
            }
            field P1 @'h8 {
                bits 3;
                access rw;
                hard_reset 'h0;
                doc {
                    In Regulator mode, defines the HIGH hurry level. In Fixed/Limiter mode, defines the Urgency level for READ transactions.
                }
            }
            field MARK @'h1f {
                access ro;
                hard_reset 'h1;
                doc {
                    Backward compatibility marker when 0.
                }
            }
            doc {
                Priority register.Priority register.
            }
        }
        register sip3_cdf_axi_I_main_QosGenerator_Mode @0xC {
            bytes 4;
            field MODE @'h0 {
                bits 2;
                access rw;
                hard_reset 'h3;
                doc {
                    Functional Mode: 0=Fixed, 1=Limiter, 2=Bypass, 3=Regulator.
                }
            }
        }
        register sip3_cdf_axi_I_main_QosGenerator_Bandwidth @0x10 {
            bytes 4;
            field BANDWIDTH @'h0 {
                bits 16;
                access rw;
                hard_reset 'h5ed0;
                doc {
                    Defines the bandwidth threshold in 1/256th-byte-per-cycle units. In other words, the desired rate in MBps is divided by frequency in MHz of the NIU, and then multiplied by 256.
                }
            }
        }
        register sip3_cdf_axi_I_main_QosGenerator_Saturation @0x14 {
            bytes 4;
            field SATURATION @'h0 {
                bits 10;
                access rw;
                hard_reset 'h8;
                doc {
                    Defines the size of the bandwidth counter, that is, the measurement window, in 16-byte units. In other words, the desired number of bytes divided by 16.
                }
            }
        }
        register sip3_cdf_axi_I_main_QosGenerator_ExtControl @0x18 {
            bytes 4;
            field SOCKETQOSEN @'h0 {
                access rw;
                hard_reset 'h0;
                doc {
                    Register field SocketQosEn determines how priority levels are driven when QoS generators and socket interfaces alternatively drive the levels for Urgency, Pressure, and Hurry signals: When set to 0, the QoS generator drives the levels. When set to 1, internal signals Pressure and Hurry are driven by the greater of the two levels from the socket interface or the QoS generator.
                }
            }
            field EXTTHREN @'h1 {
                access rw;
                hard_reset 'h0;
                doc {
                    When register field ExtThrEn is set, internal signals Urgency, Press and Hurry are driven, when input signal ExtThr is low, by the value in register Priority field P0. When ExtThr is high, they are drven by the value in register Priority field P1.
                }
            }
            field INTCLKEN @'h2 {
                access rw;
                hard_reset 'h0;
                doc {
                    When set to 1, register field IntClkEn causes the QoS generator to use the NIU clock for bandwidth calculation. When set to 0, and if configuration parameter useExternalReference is set to True, an external reference clock at the socket is used for bandwidth calculation.
                }
            }
            field EXTLIMITEN @'h3 {
                access rw;
                hard_reset 'h0;
                doc {
                    When register field ExtLimitEn is set, the bandwidth limiter is enabled when input signal ExtThr is asserted. When the signal is not asserted, the limiter is disabled: bandwidth is not limited, and the counter is stuck to 0. When the bit is cleared, the limiter operates normally and ignores ExtThr.
                }
            }
            doc {
                External inputs control.External inputs control.
            }
        }
        register sip3_cdf_axi_I_main_QosGenerator_Reserved_00 @0x1C {
            bytes 4;
            field sip3_cdf_axi_I_main_QosGenerator_Reserved_00 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip3_cdf_axi_I_main_QosGenerator_Reserved_01 @0x20 {
            bytes 4;
            field sip3_cdf_axi_I_main_QosGenerator_Reserved_01 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip3_cdf_axi_I_main_QosGenerator_Reserved_02 @0x24 {
            bytes 4;
            field sip3_cdf_axi_I_main_QosGenerator_Reserved_02 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip3_cdf_axi_I_main_QosGenerator_Reserved_03 @0x28 {
            bytes 4;
            field sip3_cdf_axi_I_main_QosGenerator_Reserved_03 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip3_cdf_axi_I_main_QosGenerator_Reserved_04 @0x2C {
            bytes 4;
            field sip3_cdf_axi_I_main_QosGenerator_Reserved_04 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip3_cdf_axi_I_main_QosGenerator_Reserved_05 @0x30 {
            bytes 4;
            field sip3_cdf_axi_I_main_QosGenerator_Reserved_05 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip3_cdf_axi_I_main_QosGenerator_Reserved_06 @0x34 {
            bytes 4;
            field sip3_cdf_axi_I_main_QosGenerator_Reserved_06 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip3_cdf_axi_I_main_QosGenerator_Reserved_07 @0x38 {
            bytes 4;
            field sip3_cdf_axi_I_main_QosGenerator_Reserved_07 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip3_cdf_axi_I_main_QosGenerator_Reserved_08 @0x3C {
            bytes 4;
            field sip3_cdf_axi_I_main_QosGenerator_Reserved_08 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip3_cdf_axi_I_main_QosGenerator_Reserved_09 @0x40 {
            bytes 4;
            field sip3_cdf_axi_I_main_QosGenerator_Reserved_09 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip3_cdf_axi_I_main_QosGenerator_Reserved_10 @0x44 {
            bytes 4;
            field sip3_cdf_axi_I_main_QosGenerator_Reserved_10 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip3_cdf_axi_I_main_QosGenerator_Reserved_11 @0x48 {
            bytes 4;
            field sip3_cdf_axi_I_main_QosGenerator_Reserved_11 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip3_cdf_axi_I_main_QosGenerator_Reserved_12 @0x4C {
            bytes 4;
            field sip3_cdf_axi_I_main_QosGenerator_Reserved_12 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip3_cdf_axi_I_main_QosGenerator_Reserved_13 @0x50 {
            bytes 4;
            field sip3_cdf_axi_I_main_QosGenerator_Reserved_13 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip3_cdf_axi_I_main_QosGenerator_Reserved_14 @0x54 {
            bytes 4;
            field sip3_cdf_axi_I_main_QosGenerator_Reserved_14 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip3_cdf_axi_I_main_QosGenerator_Reserved_15 @0x58 {
            bytes 4;
            field sip3_cdf_axi_I_main_QosGenerator_Reserved_15 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip3_cdf_axi_I_main_QosGenerator_Reserved_16 @0x5C {
            bytes 4;
            field sip3_cdf_axi_I_main_QosGenerator_Reserved_16 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip3_cdf_axi_I_main_QosGenerator_Reserved_17 @0x60 {
            bytes 4;
            field sip3_cdf_axi_I_main_QosGenerator_Reserved_17 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip3_cdf_axi_I_main_QosGenerator_Reserved_18 @0x64 {
            bytes 4;
            field sip3_cdf_axi_I_main_QosGenerator_Reserved_18 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip3_cdf_axi_I_main_QosGenerator_Reserved_19 @0x68 {
            bytes 4;
            field sip3_cdf_axi_I_main_QosGenerator_Reserved_19 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip3_cdf_axi_I_main_QosGenerator_Reserved_20 @0x6C {
            bytes 4;
            field sip3_cdf_axi_I_main_QosGenerator_Reserved_20 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip3_cdf_axi_I_main_QosGenerator_Reserved_21 @0x70 {
            bytes 4;
            field sip3_cdf_axi_I_main_QosGenerator_Reserved_21 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip3_cdf_axi_I_main_QosGenerator_Reserved_22 @0x74 {
            bytes 4;
            field sip3_cdf_axi_I_main_QosGenerator_Reserved_22 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip3_cdf_axi_I_main_QosGenerator_Reserved_23 @0x78 {
            bytes 4;
            field sip3_cdf_axi_I_main_QosGenerator_Reserved_23 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip3_cdf_axi_I_main_QosGenerator_Reserved_24 @0x7C {
            bytes 4;
            field sip3_cdf_axi_I_main_QosGenerator_Reserved_24 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
    }
    block sip4_cdf_axi_I_main_QosGenerator @0x7B00 {
        bytes 4;
        register sip4_cdf_axi_I_main_QosGenerator_Id_CoreId @0x0 {
            bytes 4;
            field CORETYPEID @'h0 {
                bits 8;
                access ro;
                hard_reset 'h4;
                doc {
                    Field identifying the type of IP.
                }
            }
            field CORECHECKSUM @'h8 {
                bits 24;
                access ro;
                hard_reset 'h44f4bc;
                doc {
                    Field containing a checksum of the parameters of the IP.
                }
            }
        }
        register sip4_cdf_axi_I_main_QosGenerator_Id_RevisionId @0x4 {
            bytes 4;
            field USERID @'h0 {
                bits 8;
                access ro;
                hard_reset 'h0;
                doc {
                    Field containing a user defined value, not used anywhere inside the IP itself.
                }
            }
            field FLEXNOCID @'h8 {
                bits 24;
                access ro;
                hard_reset 'h84f8c6;
                doc {
                    Field containing the build revision of the software used to generate the IP HDL code.
                }
            }
        }
        register sip4_cdf_axi_I_main_QosGenerator_Priority @0x8 {
            bytes 4;
            field P0 @'h0 {
                bits 3;
                access rw;
                hard_reset 'h0;
                doc {
                    In Regulator mode, defines the LOW hurry level. In Fixed/Limiter mode, defines the Urgency level for WRITE transactions.
                }
            }
            field P1 @'h8 {
                bits 3;
                access rw;
                hard_reset 'h0;
                doc {
                    In Regulator mode, defines the HIGH hurry level. In Fixed/Limiter mode, defines the Urgency level for READ transactions.
                }
            }
            field MARK @'h1f {
                access ro;
                hard_reset 'h1;
                doc {
                    Backward compatibility marker when 0.
                }
            }
            doc {
                Priority register.Priority register.
            }
        }
        register sip4_cdf_axi_I_main_QosGenerator_Mode @0xC {
            bytes 4;
            field MODE @'h0 {
                bits 2;
                access rw;
                hard_reset 'h3;
                doc {
                    Functional Mode: 0=Fixed, 1=Limiter, 2=Bypass, 3=Regulator.
                }
            }
        }
        register sip4_cdf_axi_I_main_QosGenerator_Bandwidth @0x10 {
            bytes 4;
            field BANDWIDTH @'h0 {
                bits 16;
                access rw;
                hard_reset 'h5ed0;
                doc {
                    Defines the bandwidth threshold in 1/256th-byte-per-cycle units. In other words, the desired rate in MBps is divided by frequency in MHz of the NIU, and then multiplied by 256.
                }
            }
        }
        register sip4_cdf_axi_I_main_QosGenerator_Saturation @0x14 {
            bytes 4;
            field SATURATION @'h0 {
                bits 10;
                access rw;
                hard_reset 'h8;
                doc {
                    Defines the size of the bandwidth counter, that is, the measurement window, in 16-byte units. In other words, the desired number of bytes divided by 16.
                }
            }
        }
        register sip4_cdf_axi_I_main_QosGenerator_ExtControl @0x18 {
            bytes 4;
            field SOCKETQOSEN @'h0 {
                access rw;
                hard_reset 'h0;
                doc {
                    Register field SocketQosEn determines how priority levels are driven when QoS generators and socket interfaces alternatively drive the levels for Urgency, Pressure, and Hurry signals: When set to 0, the QoS generator drives the levels. When set to 1, internal signals Pressure and Hurry are driven by the greater of the two levels from the socket interface or the QoS generator.
                }
            }
            field EXTTHREN @'h1 {
                access rw;
                hard_reset 'h0;
                doc {
                    When register field ExtThrEn is set, internal signals Urgency, Press and Hurry are driven, when input signal ExtThr is low, by the value in register Priority field P0. When ExtThr is high, they are drven by the value in register Priority field P1.
                }
            }
            field INTCLKEN @'h2 {
                access rw;
                hard_reset 'h0;
                doc {
                    When set to 1, register field IntClkEn causes the QoS generator to use the NIU clock for bandwidth calculation. When set to 0, and if configuration parameter useExternalReference is set to True, an external reference clock at the socket is used for bandwidth calculation.
                }
            }
            field EXTLIMITEN @'h3 {
                access rw;
                hard_reset 'h0;
                doc {
                    When register field ExtLimitEn is set, the bandwidth limiter is enabled when input signal ExtThr is asserted. When the signal is not asserted, the limiter is disabled: bandwidth is not limited, and the counter is stuck to 0. When the bit is cleared, the limiter operates normally and ignores ExtThr.
                }
            }
            doc {
                External inputs control.External inputs control.
            }
        }
        register sip4_cdf_axi_I_main_QosGenerator_Reserved_00 @0x1C {
            bytes 4;
            field sip4_cdf_axi_I_main_QosGenerator_Reserved_00 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip4_cdf_axi_I_main_QosGenerator_Reserved_01 @0x20 {
            bytes 4;
            field sip4_cdf_axi_I_main_QosGenerator_Reserved_01 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip4_cdf_axi_I_main_QosGenerator_Reserved_02 @0x24 {
            bytes 4;
            field sip4_cdf_axi_I_main_QosGenerator_Reserved_02 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip4_cdf_axi_I_main_QosGenerator_Reserved_03 @0x28 {
            bytes 4;
            field sip4_cdf_axi_I_main_QosGenerator_Reserved_03 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip4_cdf_axi_I_main_QosGenerator_Reserved_04 @0x2C {
            bytes 4;
            field sip4_cdf_axi_I_main_QosGenerator_Reserved_04 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip4_cdf_axi_I_main_QosGenerator_Reserved_05 @0x30 {
            bytes 4;
            field sip4_cdf_axi_I_main_QosGenerator_Reserved_05 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip4_cdf_axi_I_main_QosGenerator_Reserved_06 @0x34 {
            bytes 4;
            field sip4_cdf_axi_I_main_QosGenerator_Reserved_06 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip4_cdf_axi_I_main_QosGenerator_Reserved_07 @0x38 {
            bytes 4;
            field sip4_cdf_axi_I_main_QosGenerator_Reserved_07 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip4_cdf_axi_I_main_QosGenerator_Reserved_08 @0x3C {
            bytes 4;
            field sip4_cdf_axi_I_main_QosGenerator_Reserved_08 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip4_cdf_axi_I_main_QosGenerator_Reserved_09 @0x40 {
            bytes 4;
            field sip4_cdf_axi_I_main_QosGenerator_Reserved_09 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip4_cdf_axi_I_main_QosGenerator_Reserved_10 @0x44 {
            bytes 4;
            field sip4_cdf_axi_I_main_QosGenerator_Reserved_10 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip4_cdf_axi_I_main_QosGenerator_Reserved_11 @0x48 {
            bytes 4;
            field sip4_cdf_axi_I_main_QosGenerator_Reserved_11 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip4_cdf_axi_I_main_QosGenerator_Reserved_12 @0x4C {
            bytes 4;
            field sip4_cdf_axi_I_main_QosGenerator_Reserved_12 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip4_cdf_axi_I_main_QosGenerator_Reserved_13 @0x50 {
            bytes 4;
            field sip4_cdf_axi_I_main_QosGenerator_Reserved_13 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip4_cdf_axi_I_main_QosGenerator_Reserved_14 @0x54 {
            bytes 4;
            field sip4_cdf_axi_I_main_QosGenerator_Reserved_14 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip4_cdf_axi_I_main_QosGenerator_Reserved_15 @0x58 {
            bytes 4;
            field sip4_cdf_axi_I_main_QosGenerator_Reserved_15 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip4_cdf_axi_I_main_QosGenerator_Reserved_16 @0x5C {
            bytes 4;
            field sip4_cdf_axi_I_main_QosGenerator_Reserved_16 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip4_cdf_axi_I_main_QosGenerator_Reserved_17 @0x60 {
            bytes 4;
            field sip4_cdf_axi_I_main_QosGenerator_Reserved_17 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip4_cdf_axi_I_main_QosGenerator_Reserved_18 @0x64 {
            bytes 4;
            field sip4_cdf_axi_I_main_QosGenerator_Reserved_18 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip4_cdf_axi_I_main_QosGenerator_Reserved_19 @0x68 {
            bytes 4;
            field sip4_cdf_axi_I_main_QosGenerator_Reserved_19 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip4_cdf_axi_I_main_QosGenerator_Reserved_20 @0x6C {
            bytes 4;
            field sip4_cdf_axi_I_main_QosGenerator_Reserved_20 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip4_cdf_axi_I_main_QosGenerator_Reserved_21 @0x70 {
            bytes 4;
            field sip4_cdf_axi_I_main_QosGenerator_Reserved_21 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip4_cdf_axi_I_main_QosGenerator_Reserved_22 @0x74 {
            bytes 4;
            field sip4_cdf_axi_I_main_QosGenerator_Reserved_22 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip4_cdf_axi_I_main_QosGenerator_Reserved_23 @0x78 {
            bytes 4;
            field sip4_cdf_axi_I_main_QosGenerator_Reserved_23 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip4_cdf_axi_I_main_QosGenerator_Reserved_24 @0x7C {
            bytes 4;
            field sip4_cdf_axi_I_main_QosGenerator_Reserved_24 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
    }
    block sip5_cdf_axi_I_main_QosGenerator @0x7B80 {
        bytes 4;
        register sip5_cdf_axi_I_main_QosGenerator_Id_CoreId @0x0 {
            bytes 4;
            field CORETYPEID @'h0 {
                bits 8;
                access ro;
                hard_reset 'h4;
                doc {
                    Field identifying the type of IP.
                }
            }
            field CORECHECKSUM @'h8 {
                bits 24;
                access ro;
                hard_reset 'hae497c;
                doc {
                    Field containing a checksum of the parameters of the IP.
                }
            }
        }
        register sip5_cdf_axi_I_main_QosGenerator_Id_RevisionId @0x4 {
            bytes 4;
            field USERID @'h0 {
                bits 8;
                access ro;
                hard_reset 'h0;
                doc {
                    Field containing a user defined value, not used anywhere inside the IP itself.
                }
            }
            field FLEXNOCID @'h8 {
                bits 24;
                access ro;
                hard_reset 'h84f8c6;
                doc {
                    Field containing the build revision of the software used to generate the IP HDL code.
                }
            }
        }
        register sip5_cdf_axi_I_main_QosGenerator_Priority @0x8 {
            bytes 4;
            field P0 @'h0 {
                bits 3;
                access rw;
                hard_reset 'h0;
                doc {
                    In Regulator mode, defines the LOW hurry level. In Fixed/Limiter mode, defines the Urgency level for WRITE transactions.
                }
            }
            field P1 @'h8 {
                bits 3;
                access rw;
                hard_reset 'h0;
                doc {
                    In Regulator mode, defines the HIGH hurry level. In Fixed/Limiter mode, defines the Urgency level for READ transactions.
                }
            }
            field MARK @'h1f {
                access ro;
                hard_reset 'h1;
                doc {
                    Backward compatibility marker when 0.
                }
            }
            doc {
                Priority register.Priority register.
            }
        }
        register sip5_cdf_axi_I_main_QosGenerator_Mode @0xC {
            bytes 4;
            field MODE @'h0 {
                bits 2;
                access rw;
                hard_reset 'h3;
                doc {
                    Functional Mode: 0=Fixed, 1=Limiter, 2=Bypass, 3=Regulator.
                }
            }
        }
        register sip5_cdf_axi_I_main_QosGenerator_Bandwidth @0x10 {
            bytes 4;
            field BANDWIDTH @'h0 {
                bits 16;
                access rw;
                hard_reset 'h5ed0;
                doc {
                    Defines the bandwidth threshold in 1/256th-byte-per-cycle units. In other words, the desired rate in MBps is divided by frequency in MHz of the NIU, and then multiplied by 256.
                }
            }
        }
        register sip5_cdf_axi_I_main_QosGenerator_Saturation @0x14 {
            bytes 4;
            field SATURATION @'h0 {
                bits 10;
                access rw;
                hard_reset 'h8;
                doc {
                    Defines the size of the bandwidth counter, that is, the measurement window, in 16-byte units. In other words, the desired number of bytes divided by 16.
                }
            }
        }
        register sip5_cdf_axi_I_main_QosGenerator_ExtControl @0x18 {
            bytes 4;
            field SOCKETQOSEN @'h0 {
                access rw;
                hard_reset 'h0;
                doc {
                    Register field SocketQosEn determines how priority levels are driven when QoS generators and socket interfaces alternatively drive the levels for Urgency, Pressure, and Hurry signals: When set to 0, the QoS generator drives the levels. When set to 1, internal signals Pressure and Hurry are driven by the greater of the two levels from the socket interface or the QoS generator.
                }
            }
            field EXTTHREN @'h1 {
                access rw;
                hard_reset 'h0;
                doc {
                    When register field ExtThrEn is set, internal signals Urgency, Press and Hurry are driven, when input signal ExtThr is low, by the value in register Priority field P0. When ExtThr is high, they are drven by the value in register Priority field P1.
                }
            }
            field INTCLKEN @'h2 {
                access rw;
                hard_reset 'h0;
                doc {
                    When set to 1, register field IntClkEn causes the QoS generator to use the NIU clock for bandwidth calculation. When set to 0, and if configuration parameter useExternalReference is set to True, an external reference clock at the socket is used for bandwidth calculation.
                }
            }
            field EXTLIMITEN @'h3 {
                access rw;
                hard_reset 'h0;
                doc {
                    When register field ExtLimitEn is set, the bandwidth limiter is enabled when input signal ExtThr is asserted. When the signal is not asserted, the limiter is disabled: bandwidth is not limited, and the counter is stuck to 0. When the bit is cleared, the limiter operates normally and ignores ExtThr.
                }
            }
            doc {
                External inputs control.External inputs control.
            }
        }
        register sip5_cdf_axi_I_main_QosGenerator_Reserved_00 @0x1C {
            bytes 4;
            field sip5_cdf_axi_I_main_QosGenerator_Reserved_00 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_QosGenerator_Reserved_01 @0x20 {
            bytes 4;
            field sip5_cdf_axi_I_main_QosGenerator_Reserved_01 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_QosGenerator_Reserved_02 @0x24 {
            bytes 4;
            field sip5_cdf_axi_I_main_QosGenerator_Reserved_02 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_QosGenerator_Reserved_03 @0x28 {
            bytes 4;
            field sip5_cdf_axi_I_main_QosGenerator_Reserved_03 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_QosGenerator_Reserved_04 @0x2C {
            bytes 4;
            field sip5_cdf_axi_I_main_QosGenerator_Reserved_04 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_QosGenerator_Reserved_05 @0x30 {
            bytes 4;
            field sip5_cdf_axi_I_main_QosGenerator_Reserved_05 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_QosGenerator_Reserved_06 @0x34 {
            bytes 4;
            field sip5_cdf_axi_I_main_QosGenerator_Reserved_06 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_QosGenerator_Reserved_07 @0x38 {
            bytes 4;
            field sip5_cdf_axi_I_main_QosGenerator_Reserved_07 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_QosGenerator_Reserved_08 @0x3C {
            bytes 4;
            field sip5_cdf_axi_I_main_QosGenerator_Reserved_08 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_QosGenerator_Reserved_09 @0x40 {
            bytes 4;
            field sip5_cdf_axi_I_main_QosGenerator_Reserved_09 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_QosGenerator_Reserved_10 @0x44 {
            bytes 4;
            field sip5_cdf_axi_I_main_QosGenerator_Reserved_10 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_QosGenerator_Reserved_11 @0x48 {
            bytes 4;
            field sip5_cdf_axi_I_main_QosGenerator_Reserved_11 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_QosGenerator_Reserved_12 @0x4C {
            bytes 4;
            field sip5_cdf_axi_I_main_QosGenerator_Reserved_12 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_QosGenerator_Reserved_13 @0x50 {
            bytes 4;
            field sip5_cdf_axi_I_main_QosGenerator_Reserved_13 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_QosGenerator_Reserved_14 @0x54 {
            bytes 4;
            field sip5_cdf_axi_I_main_QosGenerator_Reserved_14 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_QosGenerator_Reserved_15 @0x58 {
            bytes 4;
            field sip5_cdf_axi_I_main_QosGenerator_Reserved_15 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_QosGenerator_Reserved_16 @0x5C {
            bytes 4;
            field sip5_cdf_axi_I_main_QosGenerator_Reserved_16 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_QosGenerator_Reserved_17 @0x60 {
            bytes 4;
            field sip5_cdf_axi_I_main_QosGenerator_Reserved_17 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_QosGenerator_Reserved_18 @0x64 {
            bytes 4;
            field sip5_cdf_axi_I_main_QosGenerator_Reserved_18 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_QosGenerator_Reserved_19 @0x68 {
            bytes 4;
            field sip5_cdf_axi_I_main_QosGenerator_Reserved_19 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_QosGenerator_Reserved_20 @0x6C {
            bytes 4;
            field sip5_cdf_axi_I_main_QosGenerator_Reserved_20 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_QosGenerator_Reserved_21 @0x70 {
            bytes 4;
            field sip5_cdf_axi_I_main_QosGenerator_Reserved_21 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_QosGenerator_Reserved_22 @0x74 {
            bytes 4;
            field sip5_cdf_axi_I_main_QosGenerator_Reserved_22 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_QosGenerator_Reserved_23 @0x78 {
            bytes 4;
            field sip5_cdf_axi_I_main_QosGenerator_Reserved_23 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip5_cdf_axi_I_main_QosGenerator_Reserved_24 @0x7C {
            bytes 4;
            field sip5_cdf_axi_I_main_QosGenerator_Reserved_24 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
    }
    block sip6_cdf_axi_I_main_QosGenerator @0x7C00 {
        bytes 4;
        register sip6_cdf_axi_I_main_QosGenerator_Id_CoreId @0x0 {
            bytes 4;
            field CORETYPEID @'h0 {
                bits 8;
                access ro;
                hard_reset 'h4;
                doc {
                    Field identifying the type of IP.
                }
            }
            field CORECHECKSUM @'h8 {
                bits 24;
                access ro;
                hard_reset 'h9c33db;
                doc {
                    Field containing a checksum of the parameters of the IP.
                }
            }
        }
        register sip6_cdf_axi_I_main_QosGenerator_Id_RevisionId @0x4 {
            bytes 4;
            field USERID @'h0 {
                bits 8;
                access ro;
                hard_reset 'h0;
                doc {
                    Field containing a user defined value, not used anywhere inside the IP itself.
                }
            }
            field FLEXNOCID @'h8 {
                bits 24;
                access ro;
                hard_reset 'h84f8c6;
                doc {
                    Field containing the build revision of the software used to generate the IP HDL code.
                }
            }
        }
        register sip6_cdf_axi_I_main_QosGenerator_Priority @0x8 {
            bytes 4;
            field P0 @'h0 {
                bits 3;
                access rw;
                hard_reset 'h0;
                doc {
                    In Regulator mode, defines the LOW hurry level. In Fixed/Limiter mode, defines the Urgency level for WRITE transactions.
                }
            }
            field P1 @'h8 {
                bits 3;
                access rw;
                hard_reset 'h0;
                doc {
                    In Regulator mode, defines the HIGH hurry level. In Fixed/Limiter mode, defines the Urgency level for READ transactions.
                }
            }
            field MARK @'h1f {
                access ro;
                hard_reset 'h1;
                doc {
                    Backward compatibility marker when 0.
                }
            }
            doc {
                Priority register.Priority register.
            }
        }
        register sip6_cdf_axi_I_main_QosGenerator_Mode @0xC {
            bytes 4;
            field MODE @'h0 {
                bits 2;
                access rw;
                hard_reset 'h3;
                doc {
                    Functional Mode: 0=Fixed, 1=Limiter, 2=Bypass, 3=Regulator.
                }
            }
        }
        register sip6_cdf_axi_I_main_QosGenerator_Bandwidth @0x10 {
            bytes 4;
            field BANDWIDTH @'h0 {
                bits 16;
                access rw;
                hard_reset 'h5ed0;
                doc {
                    Defines the bandwidth threshold in 1/256th-byte-per-cycle units. In other words, the desired rate in MBps is divided by frequency in MHz of the NIU, and then multiplied by 256.
                }
            }
        }
        register sip6_cdf_axi_I_main_QosGenerator_Saturation @0x14 {
            bytes 4;
            field SATURATION @'h0 {
                bits 10;
                access rw;
                hard_reset 'h8;
                doc {
                    Defines the size of the bandwidth counter, that is, the measurement window, in 16-byte units. In other words, the desired number of bytes divided by 16.
                }
            }
        }
        register sip6_cdf_axi_I_main_QosGenerator_ExtControl @0x18 {
            bytes 4;
            field SOCKETQOSEN @'h0 {
                access rw;
                hard_reset 'h0;
                doc {
                    Register field SocketQosEn determines how priority levels are driven when QoS generators and socket interfaces alternatively drive the levels for Urgency, Pressure, and Hurry signals: When set to 0, the QoS generator drives the levels. When set to 1, internal signals Pressure and Hurry are driven by the greater of the two levels from the socket interface or the QoS generator.
                }
            }
            field EXTTHREN @'h1 {
                access rw;
                hard_reset 'h0;
                doc {
                    When register field ExtThrEn is set, internal signals Urgency, Press and Hurry are driven, when input signal ExtThr is low, by the value in register Priority field P0. When ExtThr is high, they are drven by the value in register Priority field P1.
                }
            }
            field INTCLKEN @'h2 {
                access rw;
                hard_reset 'h0;
                doc {
                    When set to 1, register field IntClkEn causes the QoS generator to use the NIU clock for bandwidth calculation. When set to 0, and if configuration parameter useExternalReference is set to True, an external reference clock at the socket is used for bandwidth calculation.
                }
            }
            field EXTLIMITEN @'h3 {
                access rw;
                hard_reset 'h0;
                doc {
                    When register field ExtLimitEn is set, the bandwidth limiter is enabled when input signal ExtThr is asserted. When the signal is not asserted, the limiter is disabled: bandwidth is not limited, and the counter is stuck to 0. When the bit is cleared, the limiter operates normally and ignores ExtThr.
                }
            }
            doc {
                External inputs control.External inputs control.
            }
        }
        register sip6_cdf_axi_I_main_QosGenerator_Reserved_00 @0x1C {
            bytes 4;
            field sip6_cdf_axi_I_main_QosGenerator_Reserved_00 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_QosGenerator_Reserved_01 @0x20 {
            bytes 4;
            field sip6_cdf_axi_I_main_QosGenerator_Reserved_01 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_QosGenerator_Reserved_02 @0x24 {
            bytes 4;
            field sip6_cdf_axi_I_main_QosGenerator_Reserved_02 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_QosGenerator_Reserved_03 @0x28 {
            bytes 4;
            field sip6_cdf_axi_I_main_QosGenerator_Reserved_03 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_QosGenerator_Reserved_04 @0x2C {
            bytes 4;
            field sip6_cdf_axi_I_main_QosGenerator_Reserved_04 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_QosGenerator_Reserved_05 @0x30 {
            bytes 4;
            field sip6_cdf_axi_I_main_QosGenerator_Reserved_05 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_QosGenerator_Reserved_06 @0x34 {
            bytes 4;
            field sip6_cdf_axi_I_main_QosGenerator_Reserved_06 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_QosGenerator_Reserved_07 @0x38 {
            bytes 4;
            field sip6_cdf_axi_I_main_QosGenerator_Reserved_07 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_QosGenerator_Reserved_08 @0x3C {
            bytes 4;
            field sip6_cdf_axi_I_main_QosGenerator_Reserved_08 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_QosGenerator_Reserved_09 @0x40 {
            bytes 4;
            field sip6_cdf_axi_I_main_QosGenerator_Reserved_09 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_QosGenerator_Reserved_10 @0x44 {
            bytes 4;
            field sip6_cdf_axi_I_main_QosGenerator_Reserved_10 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_QosGenerator_Reserved_11 @0x48 {
            bytes 4;
            field sip6_cdf_axi_I_main_QosGenerator_Reserved_11 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_QosGenerator_Reserved_12 @0x4C {
            bytes 4;
            field sip6_cdf_axi_I_main_QosGenerator_Reserved_12 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_QosGenerator_Reserved_13 @0x50 {
            bytes 4;
            field sip6_cdf_axi_I_main_QosGenerator_Reserved_13 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_QosGenerator_Reserved_14 @0x54 {
            bytes 4;
            field sip6_cdf_axi_I_main_QosGenerator_Reserved_14 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_QosGenerator_Reserved_15 @0x58 {
            bytes 4;
            field sip6_cdf_axi_I_main_QosGenerator_Reserved_15 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_QosGenerator_Reserved_16 @0x5C {
            bytes 4;
            field sip6_cdf_axi_I_main_QosGenerator_Reserved_16 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_QosGenerator_Reserved_17 @0x60 {
            bytes 4;
            field sip6_cdf_axi_I_main_QosGenerator_Reserved_17 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_QosGenerator_Reserved_18 @0x64 {
            bytes 4;
            field sip6_cdf_axi_I_main_QosGenerator_Reserved_18 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_QosGenerator_Reserved_19 @0x68 {
            bytes 4;
            field sip6_cdf_axi_I_main_QosGenerator_Reserved_19 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_QosGenerator_Reserved_20 @0x6C {
            bytes 4;
            field sip6_cdf_axi_I_main_QosGenerator_Reserved_20 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_QosGenerator_Reserved_21 @0x70 {
            bytes 4;
            field sip6_cdf_axi_I_main_QosGenerator_Reserved_21 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_QosGenerator_Reserved_22 @0x74 {
            bytes 4;
            field sip6_cdf_axi_I_main_QosGenerator_Reserved_22 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_QosGenerator_Reserved_23 @0x78 {
            bytes 4;
            field sip6_cdf_axi_I_main_QosGenerator_Reserved_23 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip6_cdf_axi_I_main_QosGenerator_Reserved_24 @0x7C {
            bytes 4;
            field sip6_cdf_axi_I_main_QosGenerator_Reserved_24 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
    }
    block sip7_cdf_axi_I_main_QosGenerator @0x7C80 {
        bytes 4;
        register sip7_cdf_axi_I_main_QosGenerator_Id_CoreId @0x0 {
            bytes 4;
            field CORETYPEID @'h0 {
                bits 8;
                access ro;
                hard_reset 'h4;
                doc {
                    Field identifying the type of IP.
                }
            }
            field CORECHECKSUM @'h8 {
                bits 24;
                access ro;
                hard_reset 'h9d094c;
                doc {
                    Field containing a checksum of the parameters of the IP.
                }
            }
        }
        register sip7_cdf_axi_I_main_QosGenerator_Id_RevisionId @0x4 {
            bytes 4;
            field USERID @'h0 {
                bits 8;
                access ro;
                hard_reset 'h0;
                doc {
                    Field containing a user defined value, not used anywhere inside the IP itself.
                }
            }
            field FLEXNOCID @'h8 {
                bits 24;
                access ro;
                hard_reset 'h84f8c6;
                doc {
                    Field containing the build revision of the software used to generate the IP HDL code.
                }
            }
        }
        register sip7_cdf_axi_I_main_QosGenerator_Priority @0x8 {
            bytes 4;
            field P0 @'h0 {
                bits 3;
                access rw;
                hard_reset 'h0;
                doc {
                    In Regulator mode, defines the LOW hurry level. In Fixed/Limiter mode, defines the Urgency level for WRITE transactions.
                }
            }
            field P1 @'h8 {
                bits 3;
                access rw;
                hard_reset 'h0;
                doc {
                    In Regulator mode, defines the HIGH hurry level. In Fixed/Limiter mode, defines the Urgency level for READ transactions.
                }
            }
            field MARK @'h1f {
                access ro;
                hard_reset 'h1;
                doc {
                    Backward compatibility marker when 0.
                }
            }
            doc {
                Priority register.Priority register.
            }
        }
        register sip7_cdf_axi_I_main_QosGenerator_Mode @0xC {
            bytes 4;
            field MODE @'h0 {
                bits 2;
                access rw;
                hard_reset 'h3;
                doc {
                    Functional Mode: 0=Fixed, 1=Limiter, 2=Bypass, 3=Regulator.
                }
            }
        }
        register sip7_cdf_axi_I_main_QosGenerator_Bandwidth @0x10 {
            bytes 4;
            field BANDWIDTH @'h0 {
                bits 16;
                access rw;
                hard_reset 'h5ed0;
                doc {
                    Defines the bandwidth threshold in 1/256th-byte-per-cycle units. In other words, the desired rate in MBps is divided by frequency in MHz of the NIU, and then multiplied by 256.
                }
            }
        }
        register sip7_cdf_axi_I_main_QosGenerator_Saturation @0x14 {
            bytes 4;
            field SATURATION @'h0 {
                bits 10;
                access rw;
                hard_reset 'h8;
                doc {
                    Defines the size of the bandwidth counter, that is, the measurement window, in 16-byte units. In other words, the desired number of bytes divided by 16.
                }
            }
        }
        register sip7_cdf_axi_I_main_QosGenerator_ExtControl @0x18 {
            bytes 4;
            field SOCKETQOSEN @'h0 {
                access rw;
                hard_reset 'h0;
                doc {
                    Register field SocketQosEn determines how priority levels are driven when QoS generators and socket interfaces alternatively drive the levels for Urgency, Pressure, and Hurry signals: When set to 0, the QoS generator drives the levels. When set to 1, internal signals Pressure and Hurry are driven by the greater of the two levels from the socket interface or the QoS generator.
                }
            }
            field EXTTHREN @'h1 {
                access rw;
                hard_reset 'h0;
                doc {
                    When register field ExtThrEn is set, internal signals Urgency, Press and Hurry are driven, when input signal ExtThr is low, by the value in register Priority field P0. When ExtThr is high, they are drven by the value in register Priority field P1.
                }
            }
            field INTCLKEN @'h2 {
                access rw;
                hard_reset 'h0;
                doc {
                    When set to 1, register field IntClkEn causes the QoS generator to use the NIU clock for bandwidth calculation. When set to 0, and if configuration parameter useExternalReference is set to True, an external reference clock at the socket is used for bandwidth calculation.
                }
            }
            field EXTLIMITEN @'h3 {
                access rw;
                hard_reset 'h0;
                doc {
                    When register field ExtLimitEn is set, the bandwidth limiter is enabled when input signal ExtThr is asserted. When the signal is not asserted, the limiter is disabled: bandwidth is not limited, and the counter is stuck to 0. When the bit is cleared, the limiter operates normally and ignores ExtThr.
                }
            }
            doc {
                External inputs control.External inputs control.
            }
        }
        register sip7_cdf_axi_I_main_QosGenerator_Reserved_00 @0x1C {
            bytes 4;
            field sip7_cdf_axi_I_main_QosGenerator_Reserved_00 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_QosGenerator_Reserved_01 @0x20 {
            bytes 4;
            field sip7_cdf_axi_I_main_QosGenerator_Reserved_01 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_QosGenerator_Reserved_02 @0x24 {
            bytes 4;
            field sip7_cdf_axi_I_main_QosGenerator_Reserved_02 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_QosGenerator_Reserved_03 @0x28 {
            bytes 4;
            field sip7_cdf_axi_I_main_QosGenerator_Reserved_03 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_QosGenerator_Reserved_04 @0x2C {
            bytes 4;
            field sip7_cdf_axi_I_main_QosGenerator_Reserved_04 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_QosGenerator_Reserved_05 @0x30 {
            bytes 4;
            field sip7_cdf_axi_I_main_QosGenerator_Reserved_05 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_QosGenerator_Reserved_06 @0x34 {
            bytes 4;
            field sip7_cdf_axi_I_main_QosGenerator_Reserved_06 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_QosGenerator_Reserved_07 @0x38 {
            bytes 4;
            field sip7_cdf_axi_I_main_QosGenerator_Reserved_07 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_QosGenerator_Reserved_08 @0x3C {
            bytes 4;
            field sip7_cdf_axi_I_main_QosGenerator_Reserved_08 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_QosGenerator_Reserved_09 @0x40 {
            bytes 4;
            field sip7_cdf_axi_I_main_QosGenerator_Reserved_09 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_QosGenerator_Reserved_10 @0x44 {
            bytes 4;
            field sip7_cdf_axi_I_main_QosGenerator_Reserved_10 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_QosGenerator_Reserved_11 @0x48 {
            bytes 4;
            field sip7_cdf_axi_I_main_QosGenerator_Reserved_11 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_QosGenerator_Reserved_12 @0x4C {
            bytes 4;
            field sip7_cdf_axi_I_main_QosGenerator_Reserved_12 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_QosGenerator_Reserved_13 @0x50 {
            bytes 4;
            field sip7_cdf_axi_I_main_QosGenerator_Reserved_13 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_QosGenerator_Reserved_14 @0x54 {
            bytes 4;
            field sip7_cdf_axi_I_main_QosGenerator_Reserved_14 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_QosGenerator_Reserved_15 @0x58 {
            bytes 4;
            field sip7_cdf_axi_I_main_QosGenerator_Reserved_15 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_QosGenerator_Reserved_16 @0x5C {
            bytes 4;
            field sip7_cdf_axi_I_main_QosGenerator_Reserved_16 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_QosGenerator_Reserved_17 @0x60 {
            bytes 4;
            field sip7_cdf_axi_I_main_QosGenerator_Reserved_17 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_QosGenerator_Reserved_18 @0x64 {
            bytes 4;
            field sip7_cdf_axi_I_main_QosGenerator_Reserved_18 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_QosGenerator_Reserved_19 @0x68 {
            bytes 4;
            field sip7_cdf_axi_I_main_QosGenerator_Reserved_19 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_QosGenerator_Reserved_20 @0x6C {
            bytes 4;
            field sip7_cdf_axi_I_main_QosGenerator_Reserved_20 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_QosGenerator_Reserved_21 @0x70 {
            bytes 4;
            field sip7_cdf_axi_I_main_QosGenerator_Reserved_21 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_QosGenerator_Reserved_22 @0x74 {
            bytes 4;
            field sip7_cdf_axi_I_main_QosGenerator_Reserved_22 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_QosGenerator_Reserved_23 @0x78 {
            bytes 4;
            field sip7_cdf_axi_I_main_QosGenerator_Reserved_23 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
        register sip7_cdf_axi_I_main_QosGenerator_Reserved_24 @0x7C {
            bytes 4;
            field sip7_cdf_axi_I_main_QosGenerator_Reserved_24 {
                bits 32;
                access rw;
                hard_reset 'h0;
            }
        }
    }
}

